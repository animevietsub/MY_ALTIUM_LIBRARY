*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/2.20e-02[uF]/10[V]
* Murata P/N :GRM2161X1A223JA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2161X1A223JA01 Port1 Port2
C01 Port1 N01 2.24e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.52e-11
R03 N02 N03 8.11e-03
L04 N03 N04 4.71e-11
R04 N03 N04 2.85e-01
L05 N04 N05 4.41e-11
R05 N04 N05 4.45e-03
C06 N05 N06 7.04e-08
L06 N05 N06 2.85e-11
R06 N05 N06 8.77e-02
C07 N06 N07 1.80e-08
L07 N06 N07 3.60e-11
R07 N06 N07 1.44e-01
C08 N07 N08 4.94e-09
L08 N07 N08 3.13e-11
R08 N07 N08 7.75e-02
C09 N08 N09 3.39e-12
L09 N08 N09 1.03e-10
R09 N08 N09 1.14e+02
C10 N09 Port2 1.40e-12
L10 N09 Port2 2.24e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2161X1A223JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/3.30e-02[uF]/10[V]
* Murata P/N :GRM2161X1A333JA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2161X1A333JA01 Port1 Port2
C01 Port1 N01 3.34e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.91e-11
R03 N02 N03 6.21e-03
L04 N03 N04 9.31e-12
R04 N03 N04 3.28e-01
L05 N04 N05 7.39e-11
R05 N04 N05 2.07e-01
L06 N05 N06 6.05e-11
R06 N05 N06 6.10e-03
C07 N06 N07 1.45e-07
L07 N06 N07 2.30e-11
R07 N06 N07 7.52e-02
C08 N07 N08 2.26e-08
L08 N07 N08 5.91e-11
R08 N07 N08 1.51e-01
C09 N08 N09 2.25e-08
L09 N08 N09 1.70e-11
R09 N08 N09 6.03e-02
C10 N09 N10 8.65e-12
L10 N09 N10 4.05e-11
R10 N09 N10 1.39e+01
C11 N10 Port2 2.13e-12
L11 N10 Port2 1.54e-10
R11 N10 Port2 1.00e+05
.ENDS GRM2161X1A333JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRM2161X1H103JA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2161X1H103JA01 Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.31e-11
R03 N02 N03 9.69e-03
L04 N03 N04 1.29e-11
R04 N03 N04 3.14e-01
L05 N04 N05 9.42e-11
R05 N04 N05 2.11e-01
L06 N05 N06 1.07e-10
R06 N05 N06 6.62e-03
C07 N06 N07 4.56e-08
L07 N06 N07 1.58e-11
R07 N06 N07 8.43e-02
C08 N07 N08 1.13e-08
L08 N07 N08 2.21e-11
R08 N07 N08 1.30e-01
C09 N08 N09 9.87e-12
L09 N08 N09 3.55e-11
R09 N08 N09 9.87e+00
C10 N09 Port2 1.16e-12
L10 N09 Port2 2.58e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2161X1H103JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GRM2161X1H123JA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2161X1H123JA01 Port1 Port2
C01 Port1 N01 1.18e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 7.18e-03
L04 N03 N04 1.80e-11
R04 N03 N04 5.01e-01
L05 N04 N05 9.37e-11
R05 N04 N05 2.17e-01
L06 N05 N06 1.74e-10
R06 N05 N06 6.02e-03
C07 N06 N07 4.57e-08
L07 N06 N07 2.20e-11
R07 N06 N07 1.01e-01
C08 N07 N08 1.24e-08
L08 N07 N08 2.73e-11
R08 N07 N08 1.60e-01
C09 N08 N09 4.63e-12
L09 N08 N09 7.58e-11
R09 N08 N09 3.34e+01
C10 N09 Port2 1.19e-12
L10 N09 Port2 2.72e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2161X1H123JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GRM2161X1H153JA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2161X1H153JA01 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 7.24e-03
L04 N03 N04 1.81e-11
R04 N03 N04 6.80e-01
L05 N04 N05 1.25e-10
R05 N04 N05 1.79e-01
L06 N05 N06 9.53e-11
R06 N05 N06 4.86e-03
C07 N06 N07 5.23e-08
L07 N06 N07 2.56e-11
R07 N06 N07 1.01e-01
C08 N07 N08 2.17e-08
L08 N07 N08 2.23e-11
R08 N07 N08 1.50e-01
C09 N08 N09 2.43e-11
L09 N08 N09 1.45e-11
R09 N08 N09 6.36e+00
C10 N09 Port2 8.53e-13
L10 N09 Port2 3.12e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2161X1H153JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GRM2161X1H183JA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2161X1H183JA01 Port1 Port2
C01 Port1 N01 1.81e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-12
R03 N02 N03 8.28e-03
L04 N03 N04 2.32e-11
R04 N03 N04 5.84e-01
L05 N04 N05 1.11e-10
R05 N04 N05 1.99e-01
L06 N05 N06 6.34e-11
R06 N05 N06 4.50e-03
C07 N06 N07 7.53e-08
L07 N06 N07 2.28e-11
R07 N06 N07 8.68e-02
C08 N07 N08 2.35e-08
L08 N07 N08 2.91e-11
R08 N07 N08 1.30e-01
C09 N08 N09 2.49e-11
L09 N08 N09 1.17e-11
R09 N08 N09 3.83e+00
C10 N09 Port2 8.86e-13
L10 N09 Port2 2.68e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2161X1H183JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GRM2162C1H122JA01
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C1H122JA01 Port1 Port2
C01 Port1 N01 1.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 1.26e-02
L04 N03 N04 2.13e-11
R04 N03 N04 3.54e-01
L05 N04 N05 5.72e-11
R05 N04 N05 2.50e-02
L06 N05 N06 1.35e-10
R06 N05 N06 1.04e-02
C07 N06 N07 5.61e-09
L07 N06 N07 1.11e-11
R07 N06 N07 1.58e-01
C08 N07 N08 7.25e-10
L08 N07 N08 2.73e-11
R08 N07 N08 3.96e-01
C09 N08 Port2 1.45e-12
L09 N08 Port2 3.15e-10
R09 N08 Port2 2.99e+02
.ENDS GRM2162C1H122JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GRM2162C1H152JA01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C1H152JA01 Port1 Port2
C01 Port1 N01 1.48e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 1.55e-02
L04 N03 N04 8.91e-11
R04 N03 N04 2.48e-02
C05 N04 N05 7.54e-09
L05 N04 N05 1.26e-11
R05 N04 N05 1.61e-01
C06 N05 N06 1.30e-09
L06 N05 N06 2.39e-11
R06 N05 N06 3.63e-01
C07 N06 N07 5.86e-12
L07 N06 N07 5.81e-11
R07 N06 N07 6.14e-01
C08 N07 Port2 9.19e-13
L08 N07 Port2 2.80e-10
R08 N07 Port2 1.00e+05
.ENDS GRM2162C1H152JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GRM2162C1H182JA01
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C1H182JA01 Port1 Port2
C01 Port1 N01 1.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 7.52e-03
L04 N03 N04 4.74e-11
R04 N03 N04 4.02e+00
L05 N04 N05 3.93e-11
R05 N04 N05 4.13e-01
L06 N05 N06 6.03e-11
R06 N05 N06 2.13e-02
L07 N06 N07 1.27e-10
R07 N06 N07 6.43e-03
C08 N07 N08 7.10e-09
L08 N07 N08 1.75e-11
R08 N07 N08 1.87e-01
C09 N08 N09 1.46e-09
L09 N08 N09 2.93e-11
R09 N08 N09 4.49e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.26e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2162C1H182JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GRM2162C1H222JA01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C1H222JA01 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.15e-10
R03 N02 N03 1.08e-02
L04 N03 N04 1.04e-10
R04 N03 N04 1.83e-02
C05 N04 N05 1.13e-08
L05 N04 N05 1.95e-11
R05 N04 N05 2.01e-01
C06 N05 N06 2.13e-09
L06 N05 N06 4.11e-11
R06 N05 N06 4.68e-01
C07 N06 N07 5.99e-10
L07 N06 N07 3.52e-11
R07 N06 N07 2.40e-01
C08 N07 N08 1.00e-11
L08 N07 N08 4.11e-11
R08 N07 N08 6.31e-01
C09 N08 Port2 8.54e-13
L09 N08 Port2 2.94e-10
R09 N08 Port2 2.00e+05
.ENDS GRM2162C1H222JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GRM2162C1H272JA01
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C1H272JA01 Port1 Port2
C01 Port1 N01 2.68e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.05e-11
R03 N02 N03 6.76e-03
L04 N03 N04 6.96e-11
R04 N03 N04 2.67e-01
L05 N04 N05 5.71e-11
R05 N04 N05 1.36e-02
L06 N05 N06 1.54e-10
R06 N05 N06 5.13e-03
C07 N06 N07 1.62e-08
L07 N06 N07 1.73e-11
R07 N06 N07 2.45e-01
C08 N07 N08 3.46e-09
L08 N07 N08 3.31e-11
R08 N07 N08 4.98e-01
C09 N08 N09 1.09e-12
L09 N08 N09 3.04e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 4.21e-12
L10 N09 Port2 7.26e-11
R10 N09 Port2 1.74e+01
.ENDS GRM2162C1H272JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GRM2162C1H332JA01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C1H332JA01 Port1 Port2
C01 Port1 N01 3.25e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.20e-02
L04 N03 N04 7.89e-11
R04 N03 N04 4.72e-01
L05 N04 N05 6.29e-11
R05 N04 N05 1.11e-02
C06 N05 N06 1.43e-08
L06 N05 N06 2.65e-11
R06 N05 N06 2.73e-01
C07 N06 N07 4.19e-09
L07 N06 N07 3.80e-11
R07 N06 N07 4.18e-01
C08 N07 N08 2.40e-09
L08 N07 N08 2.34e-11
R08 N07 N08 1.70e-01
C09 N08 N09 3.85e-11
L09 N08 N09 1.22e-11
R09 N08 N09 3.46e-01
C10 N09 Port2 2.17e-12
L10 N09 Port2 1.12e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2162C1H332JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GRM2162C1H392JA01
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C1H392JA01 Port1 Port2
C01 Port1 N01 3.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.36e-10
R03 N02 N03 6.64e-03
L04 N03 N04 5.15e-11
R04 N03 N04 2.98e+00
L05 N04 N05 5.43e-11
R05 N04 N05 2.45e-01
L06 N05 N06 7.50e-11
R06 N05 N06 1.55e-02
L07 N06 N07 3.46e-10
R07 N06 N07 4.98e-03
C08 N07 N08 2.08e-08
L08 N07 N08 1.47e-11
R08 N07 N08 1.73e-01
C09 N08 N09 4.16e-09
L09 N08 N09 2.67e-11
R09 N08 N09 3.06e-01
C10 N09 Port2 2.48e-12
L10 N09 Port2 1.11e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2162C1H392JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GRM2162C1H472JA01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C1H472JA01 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.20e-10
R03 N02 N03 1.13e-02
L04 N03 N04 6.56e-11
R04 N03 N04 1.44e-02
C05 N04 N05 1.77e-08
L05 N04 N05 2.33e-11
R05 N04 N05 1.79e-01
C06 N05 N06 4.75e-09
L06 N05 N06 3.17e-11
R06 N05 N06 3.21e-01
C07 N06 N07 1.76e-09
L07 N06 N07 2.46e-11
R07 N06 N07 1.24e-01
C08 N07 N08 7.19e-12
L08 N07 N08 5.25e-11
R08 N07 N08 5.21e-01
C09 N08 Port2 9.13e-13
L09 N08 Port2 2.21e-10
R09 N08 Port2 1.00e+05
.ENDS GRM2162C1H472JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GRM2162C2A101JA01
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A101JA01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 7.38e-11
R03 N02 N03 1.10e-01
L04 N03 N04 1.44e-11
R04 N03 N04 3.14e-01
C05 N04 N05 5.91e-10
L05 N04 N05 9.55e-12
R05 N04 N05 7.15e-01
C06 N05 N06 7.24e-11
L06 N05 N06 2.37e-11
R06 N05 N06 1.71e+00
C07 N06 N07 2.65e-12
L07 N06 N07 7.17e-11
R07 N06 N07 9.05e+00
C08 N07 Port2 6.39e-13
L08 N07 Port2 2.96e-10
R08 N07 Port2 1.00e+05
.ENDS GRM2162C2A101JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GRM2162C2A102JA01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A102JA01 Port1 Port2
C01 Port1 N01 9.81e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-11
R03 N02 N03 2.28e-02
C04 N03 N04 1.24e-08
L04 N03 N04 8.80e-11
R04 N03 N04 2.65e-02
C05 N04 N05 3.72e-09
L05 N04 N05 1.32e-11
R05 N04 N05 1.37e-01
C06 N05 N06 5.49e-10
L06 N05 N06 2.53e-11
R06 N05 N06 3.34e-01
C07 N06 N07 4.72e-12
L07 N06 N07 5.28e-11
R07 N06 N07 8.20e-01
C08 N07 Port2 5.35e-13
L08 N07 Port2 4.19e-10
R08 N07 Port2 9.12e+04
.ENDS GRM2162C2A102JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.20e-04[uF]/100[V]
* Murata P/N :GRM2162C2A121JA01
* Property : C = 1.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A121JA01 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.76e-11
R03 N02 N03 9.81e-02
L04 N03 N04 1.09e-11
R04 N03 N04 7.43e-02
C05 N04 N05 4.44e-10
L05 N04 N05 1.55e-11
R05 N04 N05 1.04e+00
C06 N05 N06 9.74e-11
L06 N05 N06 2.16e-11
R06 N05 N06 1.95e+00
C07 N06 Port2 1.53e-12
L07 N06 Port2 2.93e-10
R07 N06 Port2 2.42e+02
.ENDS GRM2162C2A121JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GRM2162C2A122JA01
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A122JA01 Port1 Port2
C01 Port1 N01 1.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 1.26e-02
L04 N03 N04 2.13e-11
R04 N03 N04 3.54e-01
L05 N04 N05 5.72e-11
R05 N04 N05 2.50e-02
L06 N05 N06 1.35e-10
R06 N05 N06 1.04e-02
C07 N06 N07 5.61e-09
L07 N06 N07 1.11e-11
R07 N06 N07 1.58e-01
C08 N07 N08 7.25e-10
L08 N07 N08 2.73e-11
R08 N07 N08 3.96e-01
C09 N08 Port2 1.45e-12
L09 N08 Port2 3.15e-10
R09 N08 Port2 2.99e+02
.ENDS GRM2162C2A122JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.50e-04[uF]/100[V]
* Murata P/N :GRM2162C2A151JA01
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A151JA01 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.87e-10
R03 N02 N03 9.34e-02
C04 N03 N04 4.52e-10
L04 N03 N04 1.99e-11
R04 N03 N04 9.70e-01
C05 N04 N05 1.13e-10
L05 N04 N05 2.46e-11
R05 N04 N05 1.75e+00
C06 N05 N06 1.22e-11
L06 N05 N06 3.85e-11
R06 N05 N06 2.18e+00
C07 N06 Port2 1.09e-12
L07 N06 Port2 2.07e-10
R07 N06 Port2 1.00e+05
.ENDS GRM2162C2A151JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GRM2162C2A152JA01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A152JA01 Port1 Port2
C01 Port1 N01 1.48e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 1.55e-02
L04 N03 N04 8.91e-11
R04 N03 N04 2.48e-02
C05 N04 N05 7.54e-09
L05 N04 N05 1.26e-11
R05 N04 N05 1.61e-01
C06 N05 N06 1.30e-09
L06 N05 N06 2.39e-11
R06 N05 N06 3.63e-01
C07 N06 N07 5.86e-12
L07 N06 N07 5.81e-11
R07 N06 N07 6.14e-01
C08 N07 Port2 9.19e-13
L08 N07 Port2 2.80e-10
R08 N07 Port2 1.00e+05
.ENDS GRM2162C2A152JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.80e-04[uF]/100[V]
* Murata P/N :GRM2162C2A181JA01
* Property : C = 1.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A181JA01 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 8.45e-11
R03 N02 N03 9.25e-02
L04 N03 N04 9.25e-11
R04 N03 N04 1.34e+01
C05 N04 N05 7.21e-10
L05 N04 N05 1.42e-11
R05 N04 N05 6.75e-01
C06 N05 N06 1.49e-10
L06 N05 N06 2.12e-11
R06 N05 N06 1.31e+00
C07 N06 Port2 1.71e-12
L07 N06 Port2 2.75e-10
R07 N06 Port2 3.15e+02
.ENDS GRM2162C2A181JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GRM2162C2A182JA01
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A182JA01 Port1 Port2
C01 Port1 N01 1.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 7.52e-03
L04 N03 N04 4.74e-11
R04 N03 N04 4.02e+00
L05 N04 N05 3.93e-11
R05 N04 N05 4.13e-01
L06 N05 N06 6.03e-11
R06 N05 N06 2.13e-02
L07 N06 N07 1.27e-10
R07 N06 N07 6.43e-03
C08 N07 N08 7.10e-09
L08 N07 N08 1.75e-11
R08 N07 N08 1.87e-01
C09 N08 N09 1.46e-09
L09 N08 N09 2.93e-11
R09 N08 N09 4.49e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.26e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2162C2A182JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GRM2162C2A221JA01
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A221JA01 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-11
R03 N02 N03 7.72e-02
C04 N03 N04 5.84e-10
L04 N03 N04 2.45e-11
R04 N03 N04 8.99e-01
C05 N04 N05 1.71e-10
L05 N04 N05 2.79e-11
R05 N04 N05 1.59e+00
C06 N05 N06 3.45e-10
L06 N05 N06 5.95e-12
R06 N05 N06 3.77e-01
C07 N06 N07 7.62e-11
L07 N06 N07 1.40e-11
R07 N06 N07 1.10e+00
C08 N07 N08 2.81e-11
L08 N07 N08 1.64e-11
R08 N07 N08 2.02e+00
C09 N08 Port2 5.26e-13
L09 N08 Port2 3.46e-10
R09 N08 Port2 1.00e+05
.ENDS GRM2162C2A221JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GRM2162C2A222JA01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A222JA01 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.15e-10
R03 N02 N03 1.08e-02
L04 N03 N04 1.04e-10
R04 N03 N04 1.83e-02
C05 N04 N05 1.13e-08
L05 N04 N05 1.95e-11
R05 N04 N05 2.01e-01
C06 N05 N06 2.13e-09
L06 N05 N06 4.11e-11
R06 N05 N06 4.68e-01
C07 N06 N07 5.99e-10
L07 N06 N07 3.52e-11
R07 N06 N07 2.40e-01
C08 N07 N08 1.00e-11
L08 N07 N08 4.11e-11
R08 N07 N08 6.31e-01
C09 N08 Port2 8.54e-13
L09 N08 Port2 2.94e-10
R09 N08 Port2 2.00e+05
.ENDS GRM2162C2A222JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GRM2162C2A271JA01
* Property : C = 2.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A271JA01 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.08e-11
R03 N02 N03 6.90e-02
L04 N03 N04 5.69e-11
R04 N03 N04 1.90e+00
C05 N04 N05 1.04e-09
L05 N04 N05 1.98e-11
R05 N04 N05 9.94e-01
C06 N05 N06 3.04e-10
L06 N05 N06 2.35e-11
R06 N05 N06 1.31e+00
C07 N06 Port2 1.29e-12
L07 N06 Port2 3.02e-10
R07 N06 Port2 3.39e+02
.ENDS GRM2162C2A271JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GRM2162C2A272JA01
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A272JA01 Port1 Port2
C01 Port1 N01 2.68e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.05e-11
R03 N02 N03 6.76e-03
L04 N03 N04 6.96e-11
R04 N03 N04 2.67e-01
L05 N04 N05 5.71e-11
R05 N04 N05 1.36e-02
L06 N05 N06 1.54e-10
R06 N05 N06 5.13e-03
C07 N06 N07 1.62e-08
L07 N06 N07 1.73e-11
R07 N06 N07 2.45e-01
C08 N07 N08 3.46e-09
L08 N07 N08 3.31e-11
R08 N07 N08 4.98e-01
C09 N08 N09 1.09e-12
L09 N08 N09 3.04e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 4.21e-12
L10 N09 Port2 7.26e-11
R10 N09 Port2 1.74e+01
.ENDS GRM2162C2A272JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GRM2162C2A331JA01
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A331JA01 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.31e-10
R03 N02 N03 7.44e-02
L04 N03 N04 9.16e-12
R04 N03 N04 2.81e-02
C05 N04 N05 7.77e-10
L05 N04 N05 1.54e-11
R05 N04 N05 2.66e-01
C06 N05 N06 1.02e-10
L06 N05 N06 2.86e-11
R06 N05 N06 8.81e-01
C07 N06 N07 3.27e-10
L07 N06 N07 3.01e-12
R07 N06 N07 5.67e-01
C08 N07 N08 7.38e-12
L08 N07 N08 4.30e-11
R08 N07 N08 8.97e+00
C09 N08 Port2 8.08e-13
L09 N08 Port2 3.21e-10
R09 N08 Port2 1.00e+05
.ENDS GRM2162C2A331JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GRM2162C2A332JA01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A332JA01 Port1 Port2
C01 Port1 N01 3.25e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.20e-02
L04 N03 N04 7.89e-11
R04 N03 N04 4.72e-01
L05 N04 N05 6.29e-11
R05 N04 N05 1.11e-02
C06 N05 N06 1.43e-08
L06 N05 N06 2.65e-11
R06 N05 N06 2.73e-01
C07 N06 N07 4.19e-09
L07 N06 N07 3.80e-11
R07 N06 N07 4.18e-01
C08 N07 N08 2.40e-09
L08 N07 N08 2.34e-11
R08 N07 N08 1.70e-01
C09 N08 N09 3.85e-11
L09 N08 N09 1.22e-11
R09 N08 N09 3.46e-01
C10 N09 Port2 2.17e-12
L10 N09 Port2 1.12e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2162C2A332JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GRM2162C2A391JA01
* Property : C = 3.90e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A391JA01 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.23e-10
R03 N02 N03 5.29e-02
L04 N03 N04 3.19e-11
R04 N03 N04 7.68e-01
L05 N04 N05 2.05e-11
R05 N04 N05 3.64e-02
C06 N05 N06 1.61e-09
L06 N05 N06 1.07e-11
R06 N05 N06 2.17e-01
C07 N06 N07 3.53e-10
L07 N06 N07 1.38e-11
R07 N06 N07 5.29e-01
C08 N07 Port2 1.46e-12
L08 N07 Port2 3.23e-10
R08 N07 Port2 3.47e+02
.ENDS GRM2162C2A391JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GRM2162C2A392JA01
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A392JA01 Port1 Port2
C01 Port1 N01 3.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.36e-10
R03 N02 N03 6.64e-03
L04 N03 N04 5.15e-11
R04 N03 N04 2.98e+00
L05 N04 N05 5.43e-11
R05 N04 N05 2.45e-01
L06 N05 N06 7.50e-11
R06 N05 N06 1.55e-02
L07 N06 N07 3.46e-10
R07 N06 N07 4.98e-03
C08 N07 N08 2.08e-08
L08 N07 N08 1.47e-11
R08 N07 N08 1.73e-01
C09 N08 N09 4.16e-09
L09 N08 N09 2.67e-11
R09 N08 N09 3.06e-01
C10 N09 Port2 2.48e-12
L10 N09 Port2 1.11e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2162C2A392JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GRM2162C2A471JA01
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A471JA01 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-11
R03 N02 N03 6.00e-02
L04 N03 N04 4.81e-11
R04 N03 N04 1.44e+00
C05 N04 N05 1.37e-09
L05 N04 N05 1.74e-11
R05 N04 N05 2.86e-01
C06 N05 N06 2.63e-10
L06 N05 N06 2.64e-11
R06 N05 N06 6.11e-01
C07 N06 N07 2.12e-11
L07 N06 N07 2.10e-11
R07 N06 N07 2.59e+00
C08 N07 Port2 5.31e-13
L08 N07 Port2 3.94e-10
R08 N07 Port2 1.00e+05
.ENDS GRM2162C2A471JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GRM2162C2A472JA01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A472JA01 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.20e-10
R03 N02 N03 1.13e-02
L04 N03 N04 6.56e-11
R04 N03 N04 1.44e-02
C05 N04 N05 1.77e-08
L05 N04 N05 2.33e-11
R05 N04 N05 1.79e-01
C06 N05 N06 4.75e-09
L06 N05 N06 3.17e-11
R06 N05 N06 3.21e-01
C07 N06 N07 1.76e-09
L07 N06 N07 2.46e-11
R07 N06 N07 1.24e-01
C08 N07 N08 7.19e-12
L08 N07 N08 5.25e-11
R08 N07 N08 5.21e-01
C09 N08 Port2 9.13e-13
L09 N08 Port2 2.21e-10
R09 N08 Port2 1.00e+05
.ENDS GRM2162C2A472JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GRM2162C2A561JA01
* Property : C = 5.60e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A561JA01 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.06e-10
R03 N02 N03 3.60e-02
L04 N03 N04 3.08e-11
R04 N03 N04 5.35e-01
L05 N04 N05 2.97e-11
R05 N04 N05 2.78e-02
C06 N05 N06 2.77e-09
L06 N05 N06 1.17e-11
R06 N05 N06 2.63e-01
C07 N06 N07 3.93e-10
L07 N06 N07 2.60e-11
R07 N06 N07 5.46e-01
C08 N07 Port2 1.38e-12
L08 N07 Port2 3.17e-10
R08 N07 Port2 3.25e+02
.ENDS GRM2162C2A561JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GRM2162C2A681JA01
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A681JA01 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.19e-10
R03 N02 N03 4.50e-02
L04 N03 N04 6.53e-11
R04 N03 N04 1.49e+00
C05 N04 N05 2.07e-09
L05 N04 N05 2.24e-11
R05 N04 N05 4.17e-01
C06 N05 N06 5.37e-10
L06 N05 N06 2.75e-11
R06 N05 N06 6.67e-01
C07 N06 Port2 3.56e-12
L07 N06 Port2 7.25e-11
R07 N06 Port2 1.00e+05
.ENDS GRM2162C2A681JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GRM2162C2A821JA01
* Property : C = 8.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2162C2A821JA01 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.73e-11
R03 N02 N03 3.39e-02
L04 N03 N04 4.55e-11
R04 N03 N04 5.50e-01
L05 N04 N05 1.26e-11
R05 N04 N05 2.01e-02
C06 N05 N06 3.69e-09
L06 N05 N06 1.61e-11
R06 N05 N06 4.31e-01
C07 N06 N07 6.49e-10
L07 N06 N07 3.03e-11
R07 N06 N07 6.62e-01
C08 N07 Port2 1.32e-12
L08 N07 Port2 3.27e-10
R08 N07 Port2 3.61e+02
.ENDS GRM2162C2A821JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRM2163U1H103JA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2163U1H103JA01 Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.31e-11
R03 N02 N03 9.69e-03
L04 N03 N04 1.29e-11
R04 N03 N04 3.14e-01
L05 N04 N05 9.42e-11
R05 N04 N05 2.11e-01
L06 N05 N06 1.07e-10
R06 N05 N06 6.62e-03
C07 N06 N07 4.56e-08
L07 N06 N07 1.58e-11
R07 N06 N07 8.43e-02
C08 N07 N08 1.13e-08
L08 N07 N08 2.21e-11
R08 N07 N08 1.30e-01
C09 N08 N09 9.87e-12
L09 N08 N09 3.55e-11
R09 N08 N09 9.87e+00
C10 N09 Port2 1.16e-12
L10 N09 Port2 2.58e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2163U1H103JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GRM2163U1H123JA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2163U1H123JA01 Port1 Port2
C01 Port1 N01 1.18e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 7.18e-03
L04 N03 N04 1.80e-11
R04 N03 N04 5.01e-01
L05 N04 N05 9.37e-11
R05 N04 N05 2.17e-01
L06 N05 N06 1.74e-10
R06 N05 N06 6.02e-03
C07 N06 N07 4.57e-08
L07 N06 N07 2.20e-11
R07 N06 N07 1.01e-01
C08 N07 N08 1.24e-08
L08 N07 N08 2.73e-11
R08 N07 N08 1.60e-01
C09 N08 N09 4.63e-12
L09 N08 N09 7.58e-11
R09 N08 N09 3.34e+01
C10 N09 Port2 1.19e-12
L10 N09 Port2 2.72e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2163U1H123JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GRM2163U1H153JA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2163U1H153JA01 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 7.24e-03
L04 N03 N04 1.81e-11
R04 N03 N04 6.80e-01
L05 N04 N05 1.25e-10
R05 N04 N05 1.79e-01
L06 N05 N06 9.53e-11
R06 N05 N06 4.86e-03
C07 N06 N07 5.23e-08
L07 N06 N07 2.56e-11
R07 N06 N07 1.01e-01
C08 N07 N08 2.17e-08
L08 N07 N08 2.23e-11
R08 N07 N08 1.50e-01
C09 N08 N09 2.43e-11
L09 N08 N09 1.45e-11
R09 N08 N09 6.36e+00
C10 N09 Port2 8.53e-13
L10 N09 Port2 3.12e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2163U1H153JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GRM2163U1H183JA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2163U1H183JA01 Port1 Port2
C01 Port1 N01 1.81e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-12
R03 N02 N03 8.28e-03
L04 N03 N04 2.32e-11
R04 N03 N04 5.84e-01
L05 N04 N05 1.11e-10
R05 N04 N05 1.99e-01
L06 N05 N06 6.34e-11
R06 N05 N06 4.50e-03
C07 N06 N07 7.53e-08
L07 N06 N07 2.28e-11
R07 N06 N07 8.68e-02
C08 N07 N08 2.35e-08
L08 N07 N08 2.91e-11
R08 N07 N08 1.30e-01
C09 N08 N09 2.49e-11
L09 N08 N09 1.17e-11
R09 N08 N09 3.83e+00
C10 N09 Port2 8.86e-13
L10 N09 Port2 2.68e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2163U1H183JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GRM2165C1H102JA01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H102JA01 Port1 Port2
C01 Port1 N01 1.01e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 8.62e-11
R03 N02 N03 1.73e-02
L04 N03 N04 5.19e-11
R04 N03 N04 1.16e+00
L05 N04 N05 7.81e-11
R05 N04 N05 2.14e-02
L06 N05 N06 2.10e-11
R06 N05 N06 2.08e-02
C07 N06 N07 3.94e-09
L07 N06 N07 1.19e-11
R07 N06 N07 1.60e-01
C08 N07 N08 6.23e-10
L08 N07 N08 2.17e-11
R08 N07 N08 3.26e-01
C09 N08 N09 3.71e-11
L09 N08 N09 9.46e-12
R09 N08 N09 4.16e+00
C10 N09 Port2 7.61e-13
L10 N09 Port2 3.66e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2165C1H102JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GRM2165C1H122JA01
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H122JA01 Port1 Port2
C01 Port1 N01 1.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 1.26e-02
L04 N03 N04 2.13e-11
R04 N03 N04 3.54e-01
L05 N04 N05 5.72e-11
R05 N04 N05 2.50e-02
L06 N05 N06 1.35e-10
R06 N05 N06 1.04e-02
C07 N06 N07 5.61e-09
L07 N06 N07 1.11e-11
R07 N06 N07 1.58e-01
C08 N07 N08 7.25e-10
L08 N07 N08 2.73e-11
R08 N07 N08 3.96e-01
C09 N08 Port2 1.45e-12
L09 N08 Port2 3.15e-10
R09 N08 Port2 2.99e+02
.ENDS GRM2165C1H122JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GRM2165C1H152JA01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H152JA01 Port1 Port2
C01 Port1 N01 1.48e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 1.55e-02
L04 N03 N04 8.91e-11
R04 N03 N04 2.48e-02
C05 N04 N05 7.54e-09
L05 N04 N05 1.26e-11
R05 N04 N05 1.61e-01
C06 N05 N06 1.30e-09
L06 N05 N06 2.39e-11
R06 N05 N06 3.63e-01
C07 N06 N07 5.86e-12
L07 N06 N07 5.81e-11
R07 N06 N07 6.14e-01
C08 N07 Port2 9.19e-13
L08 N07 Port2 2.80e-10
R08 N07 Port2 1.00e+05
.ENDS GRM2165C1H152JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GRM2165C1H182JA01
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H182JA01 Port1 Port2
C01 Port1 N01 1.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 7.52e-03
L04 N03 N04 4.74e-11
R04 N03 N04 4.02e+00
L05 N04 N05 3.93e-11
R05 N04 N05 4.13e-01
L06 N05 N06 6.03e-11
R06 N05 N06 2.13e-02
L07 N06 N07 1.27e-10
R07 N06 N07 6.43e-03
C08 N07 N08 7.10e-09
L08 N07 N08 1.75e-11
R08 N07 N08 1.87e-01
C09 N08 N09 1.46e-09
L09 N08 N09 2.93e-11
R09 N08 N09 4.49e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.26e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2165C1H182JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GRM2165C1H183GA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H183GA01 Port1 Port2
C01 Port1 N01 1.80e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 4.70e-03
L04 N03 N04 1.87e-11
R04 N03 N04 1.95e-01
L05 N04 N05 5.81e-11
R05 N04 N05 8.90e-02
L06 N05 N06 1.06e-10
R06 N05 N06 5.72e-03
L07 N06 N07 8.77e-10
R07 N06 N07 2.36e-03
C08 N07 N08 7.99e-08
L08 N07 N08 1.85e-11
R08 N07 N08 8.42e-02
C09 N08 N09 2.10e-08
L09 N08 N09 2.61e-11
R09 N08 N09 1.39e-01
C10 N09 N10 1.30e-08
L10 N09 N10 1.02e-11
R10 N09 N10 4.15e-02
C11 N10 Port2 2.47e-12
L11 N10 Port2 1.36e-10
R11 N10 Port2 1.36e+02
.ENDS GRM2165C1H183GA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GRM2165C1H183JA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H183JA01 Port1 Port2
C01 Port1 N01 1.80e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 4.70e-03
L04 N03 N04 1.87e-11
R04 N03 N04 1.95e-01
L05 N04 N05 5.81e-11
R05 N04 N05 8.90e-02
L06 N05 N06 1.06e-10
R06 N05 N06 5.72e-03
L07 N06 N07 8.77e-10
R07 N06 N07 2.36e-03
C08 N07 N08 7.99e-08
L08 N07 N08 1.85e-11
R08 N07 N08 8.42e-02
C09 N08 N09 2.10e-08
L09 N08 N09 2.61e-11
R09 N08 N09 1.39e-01
C10 N09 N10 1.30e-08
L10 N09 N10 1.02e-11
R10 N09 N10 4.15e-02
C11 N10 Port2 2.47e-12
L11 N10 Port2 1.36e-10
R11 N10 Port2 1.36e+02
.ENDS GRM2165C1H183JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GRM2165C1H222JA01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H222JA01 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.15e-10
R03 N02 N03 1.08e-02
L04 N03 N04 1.04e-10
R04 N03 N04 1.83e-02
C05 N04 N05 1.13e-08
L05 N04 N05 1.95e-11
R05 N04 N05 2.01e-01
C06 N05 N06 2.13e-09
L06 N05 N06 4.11e-11
R06 N05 N06 4.68e-01
C07 N06 N07 5.99e-10
L07 N06 N07 3.52e-11
R07 N06 N07 2.40e-01
C08 N07 N08 1.00e-11
L08 N07 N08 4.11e-11
R08 N07 N08 6.31e-01
C09 N08 Port2 8.54e-13
L09 N08 Port2 2.94e-10
R09 N08 Port2 2.00e+05
.ENDS GRM2165C1H222JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRM2165C1H223GA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H223GA01 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.37e-10
R03 N02 N03 4.56e-03
L04 N03 N04 1.61e-11
R04 N03 N04 2.22e-01
L05 N04 N05 7.77e-11
R05 N04 N05 1.08e-01
L06 N05 N06 8.56e-11
R06 N05 N06 4.52e-03
L07 N06 N07 4.37e-10
R07 N06 N07 2.01e-03
C08 N07 N08 9.52e-08
L08 N07 N08 2.07e-11
R08 N07 N08 9.03e-02
C09 N08 N09 2.66e-08
L09 N08 N09 2.86e-11
R09 N08 N09 1.46e-01
C10 N09 N10 2.75e-08
L10 N09 N10 7.45e-12
R10 N09 N10 3.09e-02
C11 N10 Port2 3.46e-12
L11 N10 Port2 8.83e-11
R11 N10 Port2 1.16e+02
.ENDS GRM2165C1H223GA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRM2165C1H223JA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H223JA01 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.37e-10
R03 N02 N03 4.56e-03
L04 N03 N04 1.61e-11
R04 N03 N04 2.22e-01
L05 N04 N05 7.77e-11
R05 N04 N05 1.08e-01
L06 N05 N06 8.56e-11
R06 N05 N06 4.52e-03
L07 N06 N07 4.37e-10
R07 N06 N07 2.01e-03
C08 N07 N08 9.52e-08
L08 N07 N08 2.07e-11
R08 N07 N08 9.03e-02
C09 N08 N09 2.66e-08
L09 N08 N09 2.86e-11
R09 N08 N09 1.46e-01
C10 N09 N10 2.75e-08
L10 N09 N10 7.45e-12
R10 N09 N10 3.09e-02
C11 N10 Port2 3.46e-12
L11 N10 Port2 8.83e-11
R11 N10 Port2 1.16e+02
.ENDS GRM2165C1H223JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GRM2165C1H272JA01
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H272JA01 Port1 Port2
C01 Port1 N01 2.73e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 5.00e-13
R03 N02 N03 8.94e-03
L04 N03 N04 1.46e-11
R04 N03 N04 6.66e-01
L05 N04 N05 8.75e-11
R05 N04 N05 4.83e-01
L06 N05 N06 7.88e-11
R06 N05 N06 1.84e-02
C07 N06 N07 1.00e-08
L07 N06 N07 2.90e-11
R07 N06 N07 2.84e-01
C08 N07 N08 2.55e-09
L08 N07 N08 4.52e-11
R08 N07 N08 5.75e-01
C09 N08 N09 2.85e-09
L09 N08 N09 1.27e-11
R09 N08 N09 1.31e-01
C10 N09 N10 3.65e-11
L10 N09 N10 9.60e-12
R10 N09 N10 4.23e+00
C11 N10 Port2 7.76e-13
L11 N10 Port2 3.59e-10
R11 N10 Port2 1.00e+05
.ENDS GRM2165C1H272JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GRM2165C1H273GA01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H273GA01 Port1 Port2
C01 Port1 N01 2.68e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 3.12e-03
L04 N03 N04 9.78e-11
R04 N03 N04 1.52e-01
L05 N04 N05 7.62e-11
R05 N04 N05 3.71e-03
L06 N05 N06 3.96e-10
R06 N05 N06 1.95e-03
C07 N06 N07 8.90e-08
L07 N06 N07 3.08e-11
R07 N06 N07 1.16e-01
C08 N07 N08 3.27e-08
L08 N07 N08 3.48e-11
R08 N07 N08 1.65e-01
C09 N08 Port2 2.26e-12
L09 N08 Port2 1.38e-10
R09 N08 Port2 7.78e+01
.ENDS GRM2165C1H273GA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GRM2165C1H273JA01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H273JA01 Port1 Port2
C01 Port1 N01 2.68e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 3.12e-03
L04 N03 N04 9.78e-11
R04 N03 N04 1.52e-01
L05 N04 N05 7.62e-11
R05 N04 N05 3.71e-03
L06 N05 N06 3.96e-10
R06 N05 N06 1.95e-03
C07 N06 N07 8.90e-08
L07 N06 N07 3.08e-11
R07 N06 N07 1.16e-01
C08 N07 N08 3.27e-08
L08 N07 N08 3.48e-11
R08 N07 N08 1.65e-01
C09 N08 Port2 2.26e-12
L09 N08 Port2 1.38e-10
R09 N08 Port2 7.78e+01
.ENDS GRM2165C1H273JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GRM2165C1H331JA01
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H331JA01 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.31e-10
R03 N02 N03 7.44e-02
L04 N03 N04 9.16e-12
R04 N03 N04 2.81e-02
C05 N04 N05 7.77e-10
L05 N04 N05 1.54e-11
R05 N04 N05 2.66e-01
C06 N05 N06 1.02e-10
L06 N05 N06 2.86e-11
R06 N05 N06 8.81e-01
C07 N06 N07 3.27e-10
L07 N06 N07 3.01e-12
R07 N06 N07 5.67e-01
C08 N07 N08 7.38e-12
L08 N07 N08 4.30e-11
R08 N07 N08 8.97e+00
C09 N08 Port2 8.08e-13
L09 N08 Port2 3.21e-10
R09 N08 Port2 1.00e+05
.ENDS GRM2165C1H331JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GRM2165C1H332JA01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H332JA01 Port1 Port2
C01 Port1 N01 3.25e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.20e-02
L04 N03 N04 7.89e-11
R04 N03 N04 4.72e-01
L05 N04 N05 6.29e-11
R05 N04 N05 1.11e-02
C06 N05 N06 1.43e-08
L06 N05 N06 2.65e-11
R06 N05 N06 2.73e-01
C07 N06 N07 4.19e-09
L07 N06 N07 3.80e-11
R07 N06 N07 4.18e-01
C08 N07 N08 2.40e-09
L08 N07 N08 2.34e-11
R08 N07 N08 1.70e-01
C09 N08 N09 3.85e-11
L09 N08 N09 1.22e-11
R09 N08 N09 3.46e-01
C10 N09 Port2 2.17e-12
L10 N09 Port2 1.12e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2165C1H332JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GRM2165C1H333GA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H333GA01 Port1 Port2
C01 Port1 N01 3.32e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 3.26e-03
L04 N03 N04 4.79e-12
R04 N03 N04 2.15e-01
L05 N04 N05 9.91e-11
R05 N04 N05 1.45e-01
L06 N05 N06 5.96e-11
R06 N05 N06 3.88e-03
L07 N06 N07 3.65e-10
R07 N06 N07 1.74e-03
C08 N07 N08 1.08e-07
L08 N07 N08 3.63e-11
R08 N07 N08 1.09e-01
C09 N08 N09 3.29e-08
L09 N08 N09 4.65e-11
R09 N08 N09 1.63e-01
C10 N09 N10 4.56e-08
L10 N09 N10 1.03e-11
R10 N09 N10 3.84e-02
C11 N10 Port2 3.20e-12
L11 N10 Port2 9.66e-11
R11 N10 Port2 4.90e+01
.ENDS GRM2165C1H333GA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GRM2165C1H333JA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H333JA01 Port1 Port2
C01 Port1 N01 3.32e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 3.26e-03
L04 N03 N04 4.79e-12
R04 N03 N04 2.15e-01
L05 N04 N05 9.91e-11
R05 N04 N05 1.45e-01
L06 N05 N06 5.96e-11
R06 N05 N06 3.88e-03
L07 N06 N07 3.65e-10
R07 N06 N07 1.74e-03
C08 N07 N08 1.08e-07
L08 N07 N08 3.63e-11
R08 N07 N08 1.09e-01
C09 N08 N09 3.29e-08
L09 N08 N09 4.65e-11
R09 N08 N09 1.63e-01
C10 N09 N10 4.56e-08
L10 N09 N10 1.03e-11
R10 N09 N10 3.84e-02
C11 N10 Port2 3.20e-12
L11 N10 Port2 9.66e-11
R11 N10 Port2 4.90e+01
.ENDS GRM2165C1H333JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GRM2165C1H392JA01
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H392JA01 Port1 Port2
C01 Port1 N01 3.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.36e-10
R03 N02 N03 6.64e-03
L04 N03 N04 5.15e-11
R04 N03 N04 2.98e+00
L05 N04 N05 5.43e-11
R05 N04 N05 2.45e-01
L06 N05 N06 7.50e-11
R06 N05 N06 1.55e-02
L07 N06 N07 3.46e-10
R07 N06 N07 4.98e-03
C08 N07 N08 2.08e-08
L08 N07 N08 1.47e-11
R08 N07 N08 1.73e-01
C09 N08 N09 4.16e-09
L09 N08 N09 2.67e-11
R09 N08 N09 3.06e-01
C10 N09 Port2 2.48e-12
L10 N09 Port2 1.11e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2165C1H392JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GRM2165C1H471JA01
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H471JA01 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-11
R03 N02 N03 6.00e-02
L04 N03 N04 4.81e-11
R04 N03 N04 1.44e+00
C05 N04 N05 1.37e-09
L05 N04 N05 1.74e-11
R05 N04 N05 2.86e-01
C06 N05 N06 2.63e-10
L06 N05 N06 2.64e-11
R06 N05 N06 6.11e-01
C07 N06 N07 2.12e-11
L07 N06 N07 2.10e-11
R07 N06 N07 2.59e+00
C08 N07 Port2 5.31e-13
L08 N07 Port2 3.94e-10
R08 N07 Port2 1.00e+05
.ENDS GRM2165C1H471JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GRM2165C1H472JA01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C1H472JA01 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.20e-10
R03 N02 N03 1.13e-02
L04 N03 N04 6.56e-11
R04 N03 N04 1.44e-02
C05 N04 N05 1.77e-08
L05 N04 N05 2.33e-11
R05 N04 N05 1.79e-01
C06 N05 N06 4.75e-09
L06 N05 N06 3.17e-11
R06 N05 N06 3.21e-01
C07 N06 N07 1.76e-09
L07 N06 N07 2.46e-11
R07 N06 N07 1.24e-01
C08 N07 N08 7.19e-12
L08 N07 N08 5.25e-11
R08 N07 N08 5.21e-01
C09 N08 Port2 9.13e-13
L09 N08 Port2 2.21e-10
R09 N08 Port2 1.00e+05
.ENDS GRM2165C1H472JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/100[V]
* Murata P/N :GRM2165C2A101JA01
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A101JA01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 7.38e-11
R03 N02 N03 1.10e-01
L04 N03 N04 1.44e-11
R04 N03 N04 3.14e-01
C05 N04 N05 5.91e-10
L05 N04 N05 9.55e-12
R05 N04 N05 7.15e-01
C06 N05 N06 7.24e-11
L06 N05 N06 2.37e-11
R06 N05 N06 1.71e+00
C07 N06 N07 2.65e-12
L07 N06 N07 7.17e-11
R07 N06 N07 9.05e+00
C08 N07 Port2 6.39e-13
L08 N07 Port2 2.96e-10
R08 N07 Port2 1.00e+05
.ENDS GRM2165C2A101JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GRM2165C2A102JA01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A102JA01 Port1 Port2
C01 Port1 N01 9.81e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-11
R03 N02 N03 2.28e-02
C04 N03 N04 1.24e-08
L04 N03 N04 8.80e-11
R04 N03 N04 2.65e-02
C05 N04 N05 3.72e-09
L05 N04 N05 1.32e-11
R05 N04 N05 1.37e-01
C06 N05 N06 5.49e-10
L06 N05 N06 2.53e-11
R06 N05 N06 3.34e-01
C07 N06 N07 4.72e-12
L07 N06 N07 5.28e-11
R07 N06 N07 8.20e-01
C08 N07 Port2 5.35e-13
L08 N07 Port2 4.19e-10
R08 N07 Port2 9.12e+04
.ENDS GRM2165C2A102JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRM2165C2A103GA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A103GA01 Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.01e-10
R03 N02 N03 5.35e-03
L04 N03 N04 1.32e-11
R04 N03 N04 5.73e-01
L05 N04 N05 4.16e-11
R05 N04 N05 2.05e-01
L06 N05 N06 7.22e-11
R06 N05 N06 8.72e-03
L07 N06 N07 3.27e-10
R07 N06 N07 1.84e-03
C08 N07 N08 2.71e-08
L08 N07 N08 3.35e-11
R08 N07 N08 2.08e-01
C09 N08 N09 1.06e-08
L09 N08 N09 3.23e-11
R09 N08 N09 2.89e-01
C10 N09 N10 4.04e-09
L10 N09 N10 2.35e-11
R10 N09 N10 1.19e-01
C11 N10 Port2 3.33e-12
L11 N10 Port2 8.29e-11
R11 N10 Port2 9.40e+01
.ENDS GRM2165C2A103GA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRM2165C2A103JA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A103JA01 Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.01e-10
R03 N02 N03 5.35e-03
L04 N03 N04 1.32e-11
R04 N03 N04 5.73e-01
L05 N04 N05 4.16e-11
R05 N04 N05 2.05e-01
L06 N05 N06 7.22e-11
R06 N05 N06 8.72e-03
L07 N06 N07 3.27e-10
R07 N06 N07 1.84e-03
C08 N07 N08 2.71e-08
L08 N07 N08 3.35e-11
R08 N07 N08 2.08e-01
C09 N08 N09 1.06e-08
L09 N08 N09 3.23e-11
R09 N08 N09 2.89e-01
C10 N09 N10 4.04e-09
L10 N09 N10 2.35e-11
R10 N09 N10 1.19e-01
C11 N10 Port2 3.33e-12
L11 N10 Port2 8.29e-11
R11 N10 Port2 9.40e+01
.ENDS GRM2165C2A103JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-04[uF]/100[V]
* Murata P/N :GRM2165C2A121JA01
* Property : C = 1.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A121JA01 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.76e-11
R03 N02 N03 9.81e-02
L04 N03 N04 1.09e-11
R04 N03 N04 7.43e-02
C05 N04 N05 4.44e-10
L05 N04 N05 1.55e-11
R05 N04 N05 1.04e+00
C06 N05 N06 9.74e-11
L06 N05 N06 2.16e-11
R06 N05 N06 1.95e+00
C07 N06 Port2 1.53e-12
L07 N06 Port2 2.93e-10
R07 N06 Port2 2.42e+02
.ENDS GRM2165C2A121JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GRM2165C2A122JA01
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A122JA01 Port1 Port2
C01 Port1 N01 1.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 1.26e-02
L04 N03 N04 2.13e-11
R04 N03 N04 3.54e-01
L05 N04 N05 5.72e-11
R05 N04 N05 2.50e-02
L06 N05 N06 1.35e-10
R06 N05 N06 1.04e-02
C07 N06 N07 5.61e-09
L07 N06 N07 1.11e-11
R07 N06 N07 1.58e-01
C08 N07 N08 7.25e-10
L08 N07 N08 2.73e-11
R08 N07 N08 3.96e-01
C09 N08 Port2 1.45e-12
L09 N08 Port2 3.15e-10
R09 N08 Port2 2.99e+02
.ENDS GRM2165C2A122JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GRM2165C2A123GA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A123GA01 Port1 Port2
C01 Port1 N01 1.20e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.64e-10
R03 N02 N03 5.50e-03
L04 N03 N04 6.11e-11
R04 N03 N04 1.65e-01
L05 N04 N05 5.34e-11
R05 N04 N05 8.27e-03
L06 N05 N06 2.92e-10
R06 N05 N06 1.86e-03
C07 N06 N07 4.30e-08
L07 N06 N07 2.49e-11
R07 N06 N07 1.36e-01
C08 N07 N08 1.36e-08
L08 N07 N08 2.96e-11
R08 N07 N08 2.01e-01
C09 N08 N09 9.72e-09
L09 N08 N09 1.27e-11
R09 N08 N09 4.94e-02
C10 N09 Port2 1.86e-12
L10 N09 Port2 1.68e-10
R10 N09 Port2 8.12e+01
.ENDS GRM2165C2A123GA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GRM2165C2A123JA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A123JA01 Port1 Port2
C01 Port1 N01 1.20e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.64e-10
R03 N02 N03 5.50e-03
L04 N03 N04 6.11e-11
R04 N03 N04 1.65e-01
L05 N04 N05 5.34e-11
R05 N04 N05 8.27e-03
L06 N05 N06 2.92e-10
R06 N05 N06 1.86e-03
C07 N06 N07 4.30e-08
L07 N06 N07 2.49e-11
R07 N06 N07 1.36e-01
C08 N07 N08 1.36e-08
L08 N07 N08 2.96e-11
R08 N07 N08 2.01e-01
C09 N08 N09 9.72e-09
L09 N08 N09 1.27e-11
R09 N08 N09 4.94e-02
C10 N09 Port2 1.86e-12
L10 N09 Port2 1.68e-10
R10 N09 Port2 8.12e+01
.ENDS GRM2165C2A123JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-04[uF]/100[V]
* Murata P/N :GRM2165C2A151JA01
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A151JA01 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.87e-10
R03 N02 N03 9.34e-02
C04 N03 N04 4.52e-10
L04 N03 N04 1.99e-11
R04 N03 N04 9.70e-01
C05 N04 N05 1.13e-10
L05 N04 N05 2.46e-11
R05 N04 N05 1.75e+00
C06 N05 N06 1.22e-11
L06 N05 N06 3.85e-11
R06 N05 N06 2.18e+00
C07 N06 Port2 1.09e-12
L07 N06 Port2 2.07e-10
R07 N06 Port2 1.00e+05
.ENDS GRM2165C2A151JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GRM2165C2A152JA01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A152JA01 Port1 Port2
C01 Port1 N01 1.48e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 1.55e-02
L04 N03 N04 8.91e-11
R04 N03 N04 2.48e-02
C05 N04 N05 7.54e-09
L05 N04 N05 1.26e-11
R05 N04 N05 1.61e-01
C06 N05 N06 1.30e-09
L06 N05 N06 2.39e-11
R06 N05 N06 3.63e-01
C07 N06 N07 5.86e-12
L07 N06 N07 5.81e-11
R07 N06 N07 6.14e-01
C08 N07 Port2 9.19e-13
L08 N07 Port2 2.80e-10
R08 N07 Port2 1.00e+05
.ENDS GRM2165C2A152JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GRM2165C2A153GA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A153GA01 Port1 Port2
C01 Port1 N01 1.48e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 4.93e-03
L04 N03 N04 5.36e-11
R04 N03 N04 2.11e-01
L05 N04 N05 8.08e-11
R05 N04 N05 7.90e-03
L06 N05 N06 2.45e-10
R06 N05 N06 1.29e-03
C07 N06 N07 4.46e-08
L07 N06 N07 3.25e-11
R07 N06 N07 1.70e-01
C08 N07 N08 1.42e-08
L08 N07 N08 4.02e-11
R08 N07 N08 2.36e-01
C09 N08 N09 8.17e-09
L09 N08 N09 2.05e-11
R09 N08 N09 8.50e-02
C10 N09 Port2 3.87e-12
L10 N09 Port2 7.93e-11
R10 N09 Port2 3.39e+01
.ENDS GRM2165C2A153GA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GRM2165C2A153JA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A153JA01 Port1 Port2
C01 Port1 N01 1.48e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 4.93e-03
L04 N03 N04 5.36e-11
R04 N03 N04 2.11e-01
L05 N04 N05 8.08e-11
R05 N04 N05 7.90e-03
L06 N05 N06 2.45e-10
R06 N05 N06 1.29e-03
C07 N06 N07 4.46e-08
L07 N06 N07 3.25e-11
R07 N06 N07 1.70e-01
C08 N07 N08 1.42e-08
L08 N07 N08 4.02e-11
R08 N07 N08 2.36e-01
C09 N08 N09 8.17e-09
L09 N08 N09 2.05e-11
R09 N08 N09 8.50e-02
C10 N09 Port2 3.87e-12
L10 N09 Port2 7.93e-11
R10 N09 Port2 3.39e+01
.ENDS GRM2165C2A153JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-04[uF]/100[V]
* Murata P/N :GRM2165C2A181JA01
* Property : C = 1.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A181JA01 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 8.45e-11
R03 N02 N03 9.25e-02
L04 N03 N04 9.25e-11
R04 N03 N04 1.34e+01
C05 N04 N05 7.21e-10
L05 N04 N05 1.42e-11
R05 N04 N05 6.75e-01
C06 N05 N06 1.49e-10
L06 N05 N06 2.12e-11
R06 N05 N06 1.31e+00
C07 N06 Port2 1.71e-12
L07 N06 Port2 2.75e-10
R07 N06 Port2 3.15e+02
.ENDS GRM2165C2A181JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GRM2165C2A182JA01
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A182JA01 Port1 Port2
C01 Port1 N01 1.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 7.52e-03
L04 N03 N04 4.74e-11
R04 N03 N04 4.02e+00
L05 N04 N05 3.93e-11
R05 N04 N05 4.13e-01
L06 N05 N06 6.03e-11
R06 N05 N06 2.13e-02
L07 N06 N07 1.27e-10
R07 N06 N07 6.43e-03
C08 N07 N08 7.10e-09
L08 N07 N08 1.75e-11
R08 N07 N08 1.87e-01
C09 N08 N09 1.46e-09
L09 N08 N09 2.93e-11
R09 N08 N09 4.49e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.26e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2165C2A182JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GRM2165C2A221JA01
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A221JA01 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-11
R03 N02 N03 7.72e-02
C04 N03 N04 5.84e-10
L04 N03 N04 2.45e-11
R04 N03 N04 8.99e-01
C05 N04 N05 1.71e-10
L05 N04 N05 2.79e-11
R05 N04 N05 1.59e+00
C06 N05 N06 3.45e-10
L06 N05 N06 5.95e-12
R06 N05 N06 3.77e-01
C07 N06 N07 7.62e-11
L07 N06 N07 1.40e-11
R07 N06 N07 1.10e+00
C08 N07 N08 2.81e-11
L08 N07 N08 1.64e-11
R08 N07 N08 2.02e+00
C09 N08 Port2 5.26e-13
L09 N08 Port2 3.46e-10
R09 N08 Port2 1.00e+05
.ENDS GRM2165C2A221JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GRM2165C2A222JA01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A222JA01 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.15e-10
R03 N02 N03 1.08e-02
L04 N03 N04 1.04e-10
R04 N03 N04 1.83e-02
C05 N04 N05 1.13e-08
L05 N04 N05 1.95e-11
R05 N04 N05 2.01e-01
C06 N05 N06 2.13e-09
L06 N05 N06 4.11e-11
R06 N05 N06 4.68e-01
C07 N06 N07 5.99e-10
L07 N06 N07 3.52e-11
R07 N06 N07 2.40e-01
C08 N07 N08 1.00e-11
L08 N07 N08 4.11e-11
R08 N07 N08 6.31e-01
C09 N08 Port2 8.54e-13
L09 N08 Port2 2.94e-10
R09 N08 Port2 2.00e+05
.ENDS GRM2165C2A222JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GRM2165C2A271JA01
* Property : C = 2.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A271JA01 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.08e-11
R03 N02 N03 6.90e-02
L04 N03 N04 5.69e-11
R04 N03 N04 1.90e+00
C05 N04 N05 1.04e-09
L05 N04 N05 1.98e-11
R05 N04 N05 9.94e-01
C06 N05 N06 3.04e-10
L06 N05 N06 2.35e-11
R06 N05 N06 1.31e+00
C07 N06 Port2 1.29e-12
L07 N06 Port2 3.02e-10
R07 N06 Port2 3.39e+02
.ENDS GRM2165C2A271JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GRM2165C2A272JA01
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A272JA01 Port1 Port2
C01 Port1 N01 2.68e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.05e-11
R03 N02 N03 6.76e-03
L04 N03 N04 6.96e-11
R04 N03 N04 2.67e-01
L05 N04 N05 5.71e-11
R05 N04 N05 1.36e-02
L06 N05 N06 1.54e-10
R06 N05 N06 5.13e-03
C07 N06 N07 1.62e-08
L07 N06 N07 1.73e-11
R07 N06 N07 2.45e-01
C08 N07 N08 3.46e-09
L08 N07 N08 3.31e-11
R08 N07 N08 4.98e-01
C09 N08 N09 1.09e-12
L09 N08 N09 3.04e-10
R09 N08 N09 1.00e+05
C10 N09 Port2 4.21e-12
L10 N09 Port2 7.26e-11
R10 N09 Port2 1.74e+01
.ENDS GRM2165C2A272JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GRM2165C2A331JA01
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A331JA01 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.31e-10
R03 N02 N03 7.44e-02
L04 N03 N04 9.16e-12
R04 N03 N04 2.81e-02
C05 N04 N05 7.77e-10
L05 N04 N05 1.54e-11
R05 N04 N05 2.66e-01
C06 N05 N06 1.02e-10
L06 N05 N06 2.86e-11
R06 N05 N06 8.81e-01
C07 N06 N07 3.27e-10
L07 N06 N07 3.01e-12
R07 N06 N07 5.67e-01
C08 N07 N08 7.38e-12
L08 N07 N08 4.30e-11
R08 N07 N08 8.97e+00
C09 N08 Port2 8.08e-13
L09 N08 Port2 3.21e-10
R09 N08 Port2 1.00e+05
.ENDS GRM2165C2A331JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GRM2165C2A332JA01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A332JA01 Port1 Port2
C01 Port1 N01 3.25e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.20e-02
L04 N03 N04 7.89e-11
R04 N03 N04 4.72e-01
L05 N04 N05 6.29e-11
R05 N04 N05 1.11e-02
C06 N05 N06 1.43e-08
L06 N05 N06 2.65e-11
R06 N05 N06 2.73e-01
C07 N06 N07 4.19e-09
L07 N06 N07 3.80e-11
R07 N06 N07 4.18e-01
C08 N07 N08 2.40e-09
L08 N07 N08 2.34e-11
R08 N07 N08 1.70e-01
C09 N08 N09 3.85e-11
L09 N08 N09 1.22e-11
R09 N08 N09 3.46e-01
C10 N09 Port2 2.17e-12
L10 N09 Port2 1.12e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2165C2A332JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GRM2165C2A391JA01
* Property : C = 3.90e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A391JA01 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.23e-10
R03 N02 N03 5.29e-02
L04 N03 N04 3.19e-11
R04 N03 N04 7.68e-01
L05 N04 N05 2.05e-11
R05 N04 N05 3.64e-02
C06 N05 N06 1.61e-09
L06 N05 N06 1.07e-11
R06 N05 N06 2.17e-01
C07 N06 N07 3.53e-10
L07 N06 N07 1.38e-11
R07 N06 N07 5.29e-01
C08 N07 Port2 1.46e-12
L08 N07 Port2 3.23e-10
R08 N07 Port2 3.47e+02
.ENDS GRM2165C2A391JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GRM2165C2A392JA01
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A392JA01 Port1 Port2
C01 Port1 N01 3.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.36e-10
R03 N02 N03 6.64e-03
L04 N03 N04 5.15e-11
R04 N03 N04 2.98e+00
L05 N04 N05 5.43e-11
R05 N04 N05 2.45e-01
L06 N05 N06 7.50e-11
R06 N05 N06 1.55e-02
L07 N06 N07 3.46e-10
R07 N06 N07 4.98e-03
C08 N07 N08 2.08e-08
L08 N07 N08 1.47e-11
R08 N07 N08 1.73e-01
C09 N08 N09 4.16e-09
L09 N08 N09 2.67e-11
R09 N08 N09 3.06e-01
C10 N09 Port2 2.48e-12
L10 N09 Port2 1.11e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2165C2A392JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GRM2165C2A471JA01
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A471JA01 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-11
R03 N02 N03 6.00e-02
L04 N03 N04 4.81e-11
R04 N03 N04 1.44e+00
C05 N04 N05 1.37e-09
L05 N04 N05 1.74e-11
R05 N04 N05 2.86e-01
C06 N05 N06 2.63e-10
L06 N05 N06 2.64e-11
R06 N05 N06 6.11e-01
C07 N06 N07 2.12e-11
L07 N06 N07 2.10e-11
R07 N06 N07 2.59e+00
C08 N07 Port2 5.31e-13
L08 N07 Port2 3.94e-10
R08 N07 Port2 1.00e+05
.ENDS GRM2165C2A471JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GRM2165C2A472JA01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A472JA01 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.20e-10
R03 N02 N03 1.13e-02
L04 N03 N04 6.56e-11
R04 N03 N04 1.44e-02
C05 N04 N05 1.77e-08
L05 N04 N05 2.33e-11
R05 N04 N05 1.79e-01
C06 N05 N06 4.75e-09
L06 N05 N06 3.17e-11
R06 N05 N06 3.21e-01
C07 N06 N07 1.76e-09
L07 N06 N07 2.46e-11
R07 N06 N07 1.24e-01
C08 N07 N08 7.19e-12
L08 N07 N08 5.25e-11
R08 N07 N08 5.21e-01
C09 N08 Port2 9.13e-13
L09 N08 Port2 2.21e-10
R09 N08 Port2 1.00e+05
.ENDS GRM2165C2A472JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GRM2165C2A561JA01
* Property : C = 5.60e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A561JA01 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.06e-10
R03 N02 N03 3.60e-02
L04 N03 N04 3.08e-11
R04 N03 N04 5.35e-01
L05 N04 N05 2.97e-11
R05 N04 N05 2.78e-02
C06 N05 N06 2.77e-09
L06 N05 N06 1.17e-11
R06 N05 N06 2.63e-01
C07 N06 N07 3.93e-10
L07 N06 N07 2.60e-11
R07 N06 N07 5.46e-01
C08 N07 Port2 1.38e-12
L08 N07 Port2 3.17e-10
R08 N07 Port2 3.25e+02
.ENDS GRM2165C2A561JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GRM2165C2A562GA01
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A562GA01 Port1 Port2
C01 Port1 N01 5.60e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.98e-10
R03 N02 N03 1.13e-02
L04 N03 N04 4.40e-11
R04 N03 N04 2.37e-01
L05 N04 N05 2.20e-11
R05 N04 N05 2.33e-02
L06 N05 N06 7.56e-11
R06 N05 N06 8.22e-03
L07 N06 N07 6.94e-10
R07 N06 N07 5.28e-03
C08 N07 N08 3.80e-08
L08 N07 N08 9.09e-12
R08 N07 N08 8.46e-02
C09 N08 N09 5.97e-09
L09 N08 N09 1.87e-11
R09 N08 N09 1.65e-01
C10 N09 Port2 1.59e-12
L10 N09 Port2 1.97e-10
R10 N09 Port2 1.20e+02
.ENDS GRM2165C2A562GA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GRM2165C2A562JA01
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A562JA01 Port1 Port2
C01 Port1 N01 5.60e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.98e-10
R03 N02 N03 1.13e-02
L04 N03 N04 4.40e-11
R04 N03 N04 2.37e-01
L05 N04 N05 2.20e-11
R05 N04 N05 2.33e-02
L06 N05 N06 7.56e-11
R06 N05 N06 8.22e-03
L07 N06 N07 6.94e-10
R07 N06 N07 5.28e-03
C08 N07 N08 3.80e-08
L08 N07 N08 9.09e-12
R08 N07 N08 8.46e-02
C09 N08 N09 5.97e-09
L09 N08 N09 1.87e-11
R09 N08 N09 1.65e-01
C10 N09 Port2 1.59e-12
L10 N09 Port2 1.97e-10
R10 N09 Port2 1.20e+02
.ENDS GRM2165C2A562JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GRM2165C2A681JA01
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A681JA01 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.19e-10
R03 N02 N03 4.50e-02
L04 N03 N04 6.53e-11
R04 N03 N04 1.49e+00
C05 N04 N05 2.07e-09
L05 N04 N05 2.24e-11
R05 N04 N05 4.17e-01
C06 N05 N06 5.37e-10
L06 N05 N06 2.75e-11
R06 N05 N06 6.67e-01
C07 N06 Port2 3.56e-12
L07 N06 Port2 7.25e-11
R07 N06 Port2 1.00e+05
.ENDS GRM2165C2A681JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GRM2165C2A682GA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A682GA01 Port1 Port2
C01 Port1 N01 6.71e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 7.11e-03
L04 N03 N04 3.02e-11
R04 N03 N04 2.05e-01
L05 N04 N05 5.66e-11
R05 N04 N05 1.32e-02
L06 N05 N06 3.50e-10
R06 N05 N06 4.00e-03
C07 N06 N07 2.37e-08
L07 N06 N07 2.03e-11
R07 N06 N07 1.47e-01
C08 N07 N08 6.34e-09
L08 N07 N08 2.67e-11
R08 N07 N08 2.64e-01
C09 N08 N09 2.82e-09
L09 N08 N09 1.59e-11
R09 N08 N09 1.06e-01
C10 N09 Port2 1.57e-12
L10 N09 Port2 2.01e-10
R10 N09 Port2 1.33e+02
.ENDS GRM2165C2A682GA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GRM2165C2A682JA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A682JA01 Port1 Port2
C01 Port1 N01 6.71e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 7.11e-03
L04 N03 N04 3.02e-11
R04 N03 N04 2.05e-01
L05 N04 N05 5.66e-11
R05 N04 N05 1.32e-02
L06 N05 N06 3.50e-10
R06 N05 N06 4.00e-03
C07 N06 N07 2.37e-08
L07 N06 N07 2.03e-11
R07 N06 N07 1.47e-01
C08 N07 N08 6.34e-09
L08 N07 N08 2.67e-11
R08 N07 N08 2.64e-01
C09 N08 N09 2.82e-09
L09 N08 N09 1.59e-11
R09 N08 N09 1.06e-01
C10 N09 Port2 1.57e-12
L10 N09 Port2 2.01e-10
R10 N09 Port2 1.33e+02
.ENDS GRM2165C2A682JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GRM2165C2A821JA01
* Property : C = 8.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A821JA01 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.73e-11
R03 N02 N03 3.39e-02
L04 N03 N04 4.55e-11
R04 N03 N04 5.50e-01
L05 N04 N05 1.26e-11
R05 N04 N05 2.01e-02
C06 N05 N06 3.69e-09
L06 N05 N06 1.61e-11
R06 N05 N06 4.31e-01
C07 N06 N07 6.49e-10
L07 N06 N07 3.03e-11
R07 N06 N07 6.62e-01
C08 N07 Port2 1.32e-12
L08 N07 Port2 3.27e-10
R08 N07 Port2 3.61e+02
.ENDS GRM2165C2A821JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GRM2165C2A822GA01
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A822GA01 Port1 Port2
C01 Port1 N01 8.12e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.99e-10
R03 N02 N03 6.26e-03
L04 N03 N04 2.67e-12
R04 N03 N04 2.38e-01
L05 N04 N05 6.28e-11
R05 N04 N05 2.11e-01
L06 N05 N06 1.43e-11
R06 N05 N06 1.22e-02
L07 N06 N07 4.48e-11
R07 N06 N07 7.56e-03
L08 N07 N08 1.86e-10
R08 N07 N08 3.22e-03
C09 N08 N09 2.89e-08
L09 N08 N09 2.29e-11
R09 N08 N09 1.67e-01
C10 N09 N10 8.91e-09
L10 N09 N10 2.69e-11
R10 N09 N10 2.50e-01
C11 N10 Port2 2.53e-12
L11 N10 Port2 1.26e-10
R11 N10 Port2 4.94e+01
.ENDS GRM2165C2A822GA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GRM2165C2A822JA01
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2165C2A822JA01 Port1 Port2
C01 Port1 N01 8.12e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.99e-10
R03 N02 N03 6.26e-03
L04 N03 N04 2.67e-12
R04 N03 N04 2.38e-01
L05 N04 N05 6.28e-11
R05 N04 N05 2.11e-01
L06 N05 N06 1.43e-11
R06 N05 N06 1.22e-02
L07 N06 N07 4.48e-11
R07 N06 N07 7.56e-03
L08 N07 N08 1.86e-10
R08 N07 N08 3.22e-03
C09 N08 N09 2.89e-08
L09 N08 N09 2.29e-11
R09 N08 N09 1.67e-01
C10 N09 N10 8.91e-09
L10 N09 N10 2.69e-11
R10 N09 N10 2.50e-01
C11 N10 Port2 2.53e-12
L11 N10 Port2 1.26e-10
R11 N10 Port2 4.94e+01
.ENDS GRM2165C2A822JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/2.20e-02[uF]/10[V]
* Murata P/N :GRM2167U1A223JA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2167U1A223JA01 Port1 Port2
C01 Port1 N01 2.24e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.52e-11
R03 N02 N03 8.11e-03
L04 N03 N04 4.71e-11
R04 N03 N04 2.85e-01
L05 N04 N05 4.41e-11
R05 N04 N05 4.45e-03
C06 N05 N06 7.04e-08
L06 N05 N06 2.85e-11
R06 N05 N06 8.77e-02
C07 N06 N07 1.80e-08
L07 N06 N07 3.60e-11
R07 N06 N07 1.44e-01
C08 N07 N08 4.94e-09
L08 N07 N08 3.13e-11
R08 N07 N08 7.75e-02
C09 N08 N09 3.39e-12
L09 N08 N09 1.03e-10
R09 N08 N09 1.14e+02
C10 N09 Port2 1.40e-12
L10 N09 Port2 2.24e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2167U1A223JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/3.30e-02[uF]/10[V]
* Murata P/N :GRM2167U1A333JA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2167U1A333JA01 Port1 Port2
C01 Port1 N01 3.34e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.91e-11
R03 N02 N03 6.21e-03
L04 N03 N04 9.31e-12
R04 N03 N04 3.28e-01
L05 N04 N05 7.39e-11
R05 N04 N05 2.07e-01
L06 N05 N06 6.05e-11
R06 N05 N06 6.10e-03
C07 N06 N07 1.45e-07
L07 N06 N07 2.30e-11
R07 N06 N07 7.52e-02
C08 N07 N08 2.26e-08
L08 N07 N08 5.91e-11
R08 N07 N08 1.51e-01
C09 N08 N09 2.25e-08
L09 N08 N09 1.70e-11
R09 N08 N09 6.03e-02
C10 N09 N10 8.65e-12
L10 N09 N10 4.05e-11
R10 N09 N10 1.39e+01
C11 N10 Port2 2.13e-12
L11 N10 Port2 1.54e-10
R11 N10 Port2 1.00e+05
.ENDS GRM2167U1A333JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRM2167U1H103JA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2167U1H103JA01 Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.31e-11
R03 N02 N03 9.69e-03
L04 N03 N04 1.29e-11
R04 N03 N04 3.14e-01
L05 N04 N05 9.42e-11
R05 N04 N05 2.11e-01
L06 N05 N06 1.07e-10
R06 N05 N06 6.62e-03
C07 N06 N07 4.56e-08
L07 N06 N07 1.58e-11
R07 N06 N07 8.43e-02
C08 N07 N08 1.13e-08
L08 N07 N08 2.21e-11
R08 N07 N08 1.30e-01
C09 N08 N09 9.87e-12
L09 N08 N09 3.55e-11
R09 N08 N09 9.87e+00
C10 N09 Port2 1.16e-12
L10 N09 Port2 2.58e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2167U1H103JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GRM2167U1H123JA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2167U1H123JA01 Port1 Port2
C01 Port1 N01 1.18e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 7.18e-03
L04 N03 N04 1.80e-11
R04 N03 N04 5.01e-01
L05 N04 N05 9.37e-11
R05 N04 N05 2.17e-01
L06 N05 N06 1.74e-10
R06 N05 N06 6.02e-03
C07 N06 N07 4.57e-08
L07 N06 N07 2.20e-11
R07 N06 N07 1.01e-01
C08 N07 N08 1.24e-08
L08 N07 N08 2.73e-11
R08 N07 N08 1.60e-01
C09 N08 N09 4.63e-12
L09 N08 N09 7.58e-11
R09 N08 N09 3.34e+01
C10 N09 Port2 1.19e-12
L10 N09 Port2 2.72e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2167U1H123JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GRM2167U1H153JA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2167U1H153JA01 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 7.24e-03
L04 N03 N04 1.81e-11
R04 N03 N04 6.80e-01
L05 N04 N05 1.25e-10
R05 N04 N05 1.79e-01
L06 N05 N06 9.53e-11
R06 N05 N06 4.86e-03
C07 N06 N07 5.23e-08
L07 N06 N07 2.56e-11
R07 N06 N07 1.01e-01
C08 N07 N08 2.17e-08
L08 N07 N08 2.23e-11
R08 N07 N08 1.50e-01
C09 N08 N09 2.43e-11
L09 N08 N09 1.45e-11
R09 N08 N09 6.36e+00
C10 N09 Port2 8.53e-13
L10 N09 Port2 3.12e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2167U1H153JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GRM2167U1H183JA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2167U1H183JA01 Port1 Port2
C01 Port1 N01 1.81e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.16e-12
R03 N02 N03 8.28e-03
L04 N03 N04 2.32e-11
R04 N03 N04 5.84e-01
L05 N04 N05 1.11e-10
R05 N04 N05 1.99e-01
L06 N05 N06 6.34e-11
R06 N05 N06 4.50e-03
C07 N06 N07 7.53e-08
L07 N06 N07 2.28e-11
R07 N06 N07 8.68e-02
C08 N07 N08 2.35e-08
L08 N07 N08 2.91e-11
R08 N07 N08 1.30e-01
C09 N08 N09 2.49e-11
L09 N08 N09 1.17e-11
R09 N08 N09 3.83e+00
C10 N09 Port2 8.86e-13
L10 N09 Port2 2.68e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2167U1H183JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/4.70e-02[uF]/10[V]
* Murata P/N :GRM2191X1A473JA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2191X1A473JA01 Port1 Port2
C01 Port1 N01 4.59e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 9.77e-12
R03 N02 N03 5.10e-03
L04 N03 N04 1.99e-11
R04 N03 N04 7.20e-01
L05 N04 N05 6.65e-11
R05 N04 N05 1.60e-01
L06 N05 N06 8.81e-11
R06 N05 N06 4.56e-03
C07 N06 N07 2.18e-07
L07 N06 N07 2.75e-11
R07 N06 N07 8.79e-02
C08 N07 N08 5.22e-08
L08 N07 N08 4.85e-11
R08 N07 N08 1.44e-01
C09 N08 N09 1.23e-08
L09 N08 N09 5.80e-11
R09 N08 N09 7.27e-02
C10 N09 N10 1.26e-11
L10 N09 N10 2.79e-11
R10 N09 N10 1.23e+01
C11 N10 Port2 9.95e-13
L11 N10 Port2 3.10e-10
R11 N10 Port2 1.00e+05
.ENDS GRM2191X1A473JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/5.60e-02[uF]/10[V]
* Murata P/N :GRM2191X1A563JA01
* Property : C = 5.60e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2191X1A563JA01 Port1 Port2
C01 Port1 N01 5.52e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 2.27e-10
R03 N02 N03 4.73e-03
L04 N03 N04 1.59e-11
R04 N03 N04 1.60e-01
L05 N04 N05 1.14e-10
R05 N04 N05 1.07e-01
L06 N05 N06 7.29e-11
R06 N05 N06 2.76e-03
C07 N06 N07 2.18e-07
L07 N06 N07 3.45e-11
R07 N06 N07 9.08e-02
C08 N07 N08 6.67e-08
L08 N07 N08 4.96e-11
R08 N07 N08 1.20e-01
C09 N08 Port2 4.31e-12
L09 N08 Port2 7.80e-11
R09 N08 Port2 4.11e+01
.ENDS GRM2191X1A563JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRM2191X1H223JA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2191X1H223JA01 Port1 Port2
C01 Port1 N01 2.10e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.11e-12
R03 N02 N03 5.50e-03
L04 N03 N04 2.04e-11
R04 N03 N04 4.41e-01
L05 N04 N05 1.68e-10
R05 N04 N05 1.54e-01
L06 N05 N06 2.05e-10
R06 N05 N06 2.56e-03
C07 N06 N07 1.43e-07
L07 N06 N07 1.77e-11
R07 N06 N07 1.04e-01
C08 N07 N08 4.31e-08
L08 N07 N08 2.29e-11
R08 N07 N08 1.36e-01
C09 N08 N09 9.75e-12
L09 N08 N09 3.60e-11
R09 N08 N09 1.58e+01
C10 N09 Port2 1.02e-12
L10 N09 Port2 3.16e-10
R10 N09 Port2 7.29e+02
.ENDS GRM2191X1H223JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GRM2191X1H273JA01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2191X1H273JA01 Port1 Port2
C01 Port1 N01 2.66e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 5.64e-03
L04 N03 N04 3.55e-11
R04 N03 N04 2.02e+00
L05 N04 N05 6.94e-11
R05 N04 N05 1.68e-01
L06 N05 N06 9.97e-11
R06 N05 N06 5.48e-03
C07 N06 N07 1.20e-07
L07 N06 N07 2.72e-11
R07 N06 N07 1.07e-01
C08 N07 N08 3.37e-08
L08 N07 N08 4.25e-11
R08 N07 N08 1.39e-01
C09 N08 N09 1.20e-08
L09 N08 N09 3.62e-11
R09 N08 N09 7.56e-02
C10 N09 N10 2.65e-11
L10 N09 N10 1.32e-11
R10 N09 N10 5.83e+00
C11 N10 Port2 1.05e-12
L11 N10 Port2 2.81e-10
R11 N10 Port2 1.00e+05
.ENDS GRM2191X1H273JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRM2192C1H103JA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2192C1H103JA01 Port1 Port2
C01 Port1 N01 9.85e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 4.22e-03
L04 N03 N04 1.32e-10
R04 N03 N04 2.65e-01
L05 N04 N05 1.12e-10
R05 N04 N05 6.32e-03
C06 N05 N06 4.00e-08
L06 N05 N06 3.28e-11
R06 N05 N06 2.77e-01
C07 N06 N07 1.59e-08
L07 N06 N07 3.66e-11
R07 N06 N07 2.93e-01
C08 N07 N08 1.41e-07
L08 N07 N08 1.97e-12
R08 N07 N08 3.63e-02
C09 N08 N09 1.81e-08
L09 N08 N09 9.20e-12
R09 N08 N09 8.88e-02
C10 N09 N10 7.84e-11
L10 N09 N10 5.62e-12
R10 N09 N10 1.34e-01
C11 N10 Port2 2.36e-12
L11 N10 Port2 1.02e-10
R11 N10 Port2 1.00e+05
.ENDS GRM2192C1H103JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GRM2192C1H123JA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2192C1H123JA01 Port1 Port2
C01 Port1 N01 1.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 3.19e-03
L04 N03 N04 3.63e-11
R04 N03 N04 2.93e+00
L05 N04 N05 9.04e-11
R05 N04 N05 2.06e-01
L06 N05 N06 8.53e-11
R06 N05 N06 6.05e-03
L07 N06 N07 8.88e-09
R07 N06 N07 1.65e-03
C08 N07 N08 3.87e-08
L08 N07 N08 3.70e-11
R08 N07 N08 2.15e-01
C09 N08 N09 1.66e-08
L09 N08 N09 3.29e-11
R09 N08 N09 2.63e-01
C10 N09 Port2 2.23e-12
L10 N09 Port2 1.18e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2192C1H123JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GRM2192C1H153JA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2192C1H153JA01 Port1 Port2
C01 Port1 N01 1.48e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 3.71e-03
L04 N03 N04 1.16e-10
R04 N03 N04 2.25e-01
L05 N04 N05 6.62e-11
R05 N04 N05 3.94e-03
C06 N05 N06 4.31e-08
L06 N05 N06 4.49e-11
R06 N05 N06 2.01e-01
C07 N06 N07 1.81e-08
L07 N06 N07 4.62e-11
R07 N06 N07 2.85e-01
C08 N07 N08 6.88e-08
L08 N07 N08 5.61e-12
R08 N07 N08 5.25e-02
C09 N08 N09 3.11e-08
L09 N08 N09 7.68e-12
R09 N08 N09 1.09e-01
C10 N09 N10 5.85e-11
L10 N09 N10 8.02e-12
R10 N09 N10 2.87e-01
C11 N10 Port2 3.91e-12
L11 N10 Port2 6.67e-11
R11 N10 Port2 1.00e+05
.ENDS GRM2192C1H153JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GRM2192C1H562JA01
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2192C1H562JA01 Port1 Port2
C01 Port1 N01 5.54e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 6.08e-03
L04 N03 N04 1.80e-11
R04 N03 N04 7.53e-01
L05 N04 N05 8.50e-11
R05 N04 N05 2.64e-01
L06 N05 N06 1.04e-10
R06 N05 N06 1.16e-02
C07 N06 N07 2.35e-08
L07 N06 N07 2.79e-11
R07 N06 N07 3.06e-01
C08 N07 N08 8.88e-09
L08 N07 N08 2.99e-11
R08 N07 N08 4.04e-01
C09 N08 N09 8.22e-12
L09 N08 N09 4.00e-11
R09 N08 N09 1.43e+01
C10 N09 Port2 1.38e-12
L10 N09 Port2 2.18e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2192C1H562JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GRM2192C1H682JA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2192C1H682JA01 Port1 Port2
C01 Port1 N01 6.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.48e-11
R03 N02 N03 7.15e-03
L04 N03 N04 6.63e-11
R04 N03 N04 3.89e-01
L05 N04 N05 1.06e-10
R05 N04 N05 1.23e-02
C06 N05 N06 2.73e-08
L06 N05 N06 2.81e-11
R06 N05 N06 2.53e-01
C07 N06 N07 7.06e-09
L07 N06 N07 4.10e-11
R07 N06 N07 3.73e-01
C08 N07 N08 5.35e-09
L08 N07 N08 1.65e-11
R08 N07 N08 1.20e-01
C09 N08 N09 1.26e-10
L09 N08 N09 3.72e-12
R09 N08 N09 2.11e-01
C10 N09 Port2 7.35e-13
L10 N09 Port2 3.41e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2192C1H682JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GRM2192C1H822JA01
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2192C1H822JA01 Port1 Port2
C01 Port1 N01 8.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.89e-10
R03 N02 N03 6.14e-03
L04 N03 N04 1.45e-11
R04 N03 N04 4.64e-01
L05 N04 N05 8.80e-11
R05 N04 N05 2.41e-01
L06 N05 N06 8.20e-11
R06 N05 N06 8.61e-03
L07 N06 N07 1.33e-10
R07 N06 N07 1.51e-03
C08 N07 N08 3.63e-08
L08 N07 N08 2.60e-11
R08 N07 N08 2.02e-01
C09 N08 N09 1.07e-08
L09 N08 N09 3.61e-11
R09 N08 N09 2.80e-01
C10 N09 N10 4.29e-11
L10 N09 N10 7.76e-12
R10 N09 N10 2.14e+00
C11 N10 Port2 5.59e-12
L11 N10 Port2 5.40e-11
R11 N10 Port2 1.00e+05
.ENDS GRM2192C1H822JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRM2192C2A103JA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2192C2A103JA01 Port1 Port2
C01 Port1 N01 9.85e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 4.22e-03
L04 N03 N04 1.32e-10
R04 N03 N04 2.65e-01
L05 N04 N05 1.12e-10
R05 N04 N05 6.32e-03
C06 N05 N06 4.00e-08
L06 N05 N06 3.28e-11
R06 N05 N06 2.77e-01
C07 N06 N07 1.59e-08
L07 N06 N07 3.66e-11
R07 N06 N07 2.93e-01
C08 N07 N08 1.41e-07
L08 N07 N08 1.97e-12
R08 N07 N08 3.63e-02
C09 N08 N09 1.81e-08
L09 N08 N09 9.20e-12
R09 N08 N09 8.88e-02
C10 N09 N10 7.84e-11
L10 N09 N10 5.62e-12
R10 N09 N10 1.34e-01
C11 N10 Port2 2.36e-12
L11 N10 Port2 1.02e-10
R11 N10 Port2 1.00e+05
.ENDS GRM2192C2A103JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GRM2192C2A123JA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2192C2A123JA01 Port1 Port2
C01 Port1 N01 1.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 3.19e-03
L04 N03 N04 3.63e-11
R04 N03 N04 2.93e+00
L05 N04 N05 9.04e-11
R05 N04 N05 2.06e-01
L06 N05 N06 8.53e-11
R06 N05 N06 6.05e-03
L07 N06 N07 8.88e-09
R07 N06 N07 1.65e-03
C08 N07 N08 3.87e-08
L08 N07 N08 3.70e-11
R08 N07 N08 2.15e-01
C09 N08 N09 1.66e-08
L09 N08 N09 3.29e-11
R09 N08 N09 2.63e-01
C10 N09 Port2 2.23e-12
L10 N09 Port2 1.18e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2192C2A123JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GRM2192C2A153JA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2192C2A153JA01 Port1 Port2
C01 Port1 N01 1.48e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 3.71e-03
L04 N03 N04 1.16e-10
R04 N03 N04 2.25e-01
L05 N04 N05 6.62e-11
R05 N04 N05 3.94e-03
C06 N05 N06 4.31e-08
L06 N05 N06 4.49e-11
R06 N05 N06 2.01e-01
C07 N06 N07 1.81e-08
L07 N06 N07 4.62e-11
R07 N06 N07 2.85e-01
C08 N07 N08 6.88e-08
L08 N07 N08 5.61e-12
R08 N07 N08 5.25e-02
C09 N08 N09 3.11e-08
L09 N08 N09 7.68e-12
R09 N08 N09 1.09e-01
C10 N09 N10 5.85e-11
L10 N09 N10 8.02e-12
R10 N09 N10 2.87e-01
C11 N10 Port2 3.91e-12
L11 N10 Port2 6.67e-11
R11 N10 Port2 1.00e+05
.ENDS GRM2192C2A153JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GRM2192C2A562JA01
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2192C2A562JA01 Port1 Port2
C01 Port1 N01 5.54e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 6.08e-03
L04 N03 N04 1.80e-11
R04 N03 N04 7.53e-01
L05 N04 N05 8.50e-11
R05 N04 N05 2.64e-01
L06 N05 N06 1.04e-10
R06 N05 N06 1.16e-02
C07 N06 N07 2.35e-08
L07 N06 N07 2.79e-11
R07 N06 N07 3.06e-01
C08 N07 N08 8.88e-09
L08 N07 N08 2.99e-11
R08 N07 N08 4.04e-01
C09 N08 N09 8.22e-12
L09 N08 N09 4.00e-11
R09 N08 N09 1.43e+01
C10 N09 Port2 1.38e-12
L10 N09 Port2 2.18e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2192C2A562JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GRM2192C2A682JA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2192C2A682JA01 Port1 Port2
C01 Port1 N01 6.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.48e-11
R03 N02 N03 7.15e-03
L04 N03 N04 6.63e-11
R04 N03 N04 3.89e-01
L05 N04 N05 1.06e-10
R05 N04 N05 1.23e-02
C06 N05 N06 2.73e-08
L06 N05 N06 2.81e-11
R06 N05 N06 2.53e-01
C07 N06 N07 7.06e-09
L07 N06 N07 4.10e-11
R07 N06 N07 3.73e-01
C08 N07 N08 5.35e-09
L08 N07 N08 1.65e-11
R08 N07 N08 1.20e-01
C09 N08 N09 1.26e-10
L09 N08 N09 3.72e-12
R09 N08 N09 2.11e-01
C10 N09 Port2 7.35e-13
L10 N09 Port2 3.41e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2192C2A682JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GRM2192C2A822JA01
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2192C2A822JA01 Port1 Port2
C01 Port1 N01 8.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.89e-10
R03 N02 N03 6.14e-03
L04 N03 N04 1.45e-11
R04 N03 N04 4.64e-01
L05 N04 N05 8.80e-11
R05 N04 N05 2.41e-01
L06 N05 N06 8.20e-11
R06 N05 N06 8.61e-03
L07 N06 N07 1.33e-10
R07 N06 N07 1.51e-03
C08 N07 N08 3.63e-08
L08 N07 N08 2.60e-11
R08 N07 N08 2.02e-01
C09 N08 N09 1.07e-08
L09 N08 N09 3.61e-11
R09 N08 N09 2.80e-01
C10 N09 N10 4.29e-11
L10 N09 N10 7.76e-12
R10 N09 N10 2.14e+00
C11 N10 Port2 5.59e-12
L11 N10 Port2 5.40e-11
R11 N10 Port2 1.00e+05
.ENDS GRM2192C2A822JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/5.60e-02[uF]/10[V]
* Murata P/N :GRM2193U1A563JA01
* Property : C = 5.60e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2193U1A563JA01 Port1 Port2
C01 Port1 N01 5.52e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 2.27e-10
R03 N02 N03 4.73e-03
L04 N03 N04 1.59e-11
R04 N03 N04 1.60e-01
L05 N04 N05 1.14e-10
R05 N04 N05 1.07e-01
L06 N05 N06 7.29e-11
R06 N05 N06 2.76e-03
C07 N06 N07 2.18e-07
L07 N06 N07 3.45e-11
R07 N06 N07 9.08e-02
C08 N07 N08 6.67e-08
L08 N07 N08 4.96e-11
R08 N07 N08 1.20e-01
C09 N08 Port2 4.31e-12
L09 N08 Port2 7.80e-11
R09 N08 Port2 4.11e+01
.ENDS GRM2193U1A563JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRM2193U1H223JA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2193U1H223JA01 Port1 Port2
C01 Port1 N01 2.10e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.11e-12
R03 N02 N03 5.50e-03
L04 N03 N04 2.04e-11
R04 N03 N04 4.41e-01
L05 N04 N05 1.68e-10
R05 N04 N05 1.54e-01
L06 N05 N06 2.05e-10
R06 N05 N06 2.56e-03
C07 N06 N07 1.43e-07
L07 N06 N07 1.77e-11
R07 N06 N07 1.04e-01
C08 N07 N08 4.31e-08
L08 N07 N08 2.29e-11
R08 N07 N08 1.36e-01
C09 N08 N09 9.75e-12
L09 N08 N09 3.60e-11
R09 N08 N09 1.58e+01
C10 N09 Port2 1.02e-12
L10 N09 Port2 3.16e-10
R10 N09 Port2 7.29e+02
.ENDS GRM2193U1H223JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GRM2193U1H273JA01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2193U1H273JA01 Port1 Port2
C01 Port1 N01 2.66e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 5.64e-03
L04 N03 N04 3.55e-11
R04 N03 N04 2.02e+00
L05 N04 N05 6.94e-11
R05 N04 N05 1.68e-01
L06 N05 N06 9.97e-11
R06 N05 N06 5.48e-03
C07 N06 N07 1.20e-07
L07 N06 N07 2.72e-11
R07 N06 N07 1.07e-01
C08 N07 N08 3.37e-08
L08 N07 N08 4.25e-11
R08 N07 N08 1.39e-01
C09 N08 N09 1.20e-08
L09 N08 N09 3.62e-11
R09 N08 N09 7.56e-02
C10 N09 N10 2.65e-11
L10 N09 N10 1.32e-11
R10 N09 N10 5.83e+00
C11 N10 Port2 1.05e-12
L11 N10 Port2 2.81e-10
R11 N10 Port2 1.00e+05
.ENDS GRM2193U1H273JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRM2195C1H103JA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C1H103JA01 Port1 Port2
C01 Port1 N01 9.85e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 4.22e-03
L04 N03 N04 1.32e-10
R04 N03 N04 2.65e-01
L05 N04 N05 1.12e-10
R05 N04 N05 6.32e-03
C06 N05 N06 4.00e-08
L06 N05 N06 3.28e-11
R06 N05 N06 2.77e-01
C07 N06 N07 1.59e-08
L07 N06 N07 3.66e-11
R07 N06 N07 2.93e-01
C08 N07 N08 1.41e-07
L08 N07 N08 1.97e-12
R08 N07 N08 3.63e-02
C09 N08 N09 1.81e-08
L09 N08 N09 9.20e-12
R09 N08 N09 8.88e-02
C10 N09 N10 7.84e-11
L10 N09 N10 5.62e-12
R10 N09 N10 1.34e-01
C11 N10 Port2 2.36e-12
L11 N10 Port2 1.02e-10
R11 N10 Port2 1.00e+05
.ENDS GRM2195C1H103JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GRM2195C1H123JA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C1H123JA01 Port1 Port2
C01 Port1 N01 1.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 3.19e-03
L04 N03 N04 3.63e-11
R04 N03 N04 2.93e+00
L05 N04 N05 9.04e-11
R05 N04 N05 2.06e-01
L06 N05 N06 8.53e-11
R06 N05 N06 6.05e-03
L07 N06 N07 8.88e-09
R07 N06 N07 1.65e-03
C08 N07 N08 3.87e-08
L08 N07 N08 3.70e-11
R08 N07 N08 2.15e-01
C09 N08 N09 1.66e-08
L09 N08 N09 3.29e-11
R09 N08 N09 2.63e-01
C10 N09 Port2 2.23e-12
L10 N09 Port2 1.18e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2195C1H123JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GRM2195C1H153JA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C1H153JA01 Port1 Port2
C01 Port1 N01 1.48e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 3.71e-03
L04 N03 N04 1.16e-10
R04 N03 N04 2.25e-01
L05 N04 N05 6.62e-11
R05 N04 N05 3.94e-03
C06 N05 N06 4.31e-08
L06 N05 N06 4.49e-11
R06 N05 N06 2.01e-01
C07 N06 N07 1.81e-08
L07 N06 N07 4.62e-11
R07 N06 N07 2.85e-01
C08 N07 N08 6.88e-08
L08 N07 N08 5.61e-12
R08 N07 N08 5.25e-02
C09 N08 N09 3.11e-08
L09 N08 N09 7.68e-12
R09 N08 N09 1.09e-01
C10 N09 N10 5.85e-11
L10 N09 N10 8.02e-12
R10 N09 N10 2.87e-01
C11 N10 Port2 3.91e-12
L11 N10 Port2 6.67e-11
R11 N10 Port2 1.00e+05
.ENDS GRM2195C1H153JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GRM2195C1H562JA01
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C1H562JA01 Port1 Port2
C01 Port1 N01 5.70e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 4.66e-03
L04 N03 N04 1.04e-10
R04 N03 N04 3.42e-01
L05 N04 N05 8.94e-11
R05 N04 N05 7.30e-03
L06 N05 N06 6.66e-11
R06 N05 N06 1.34e-03
C07 N06 N07 1.63e-08
L07 N06 N07 4.04e-11
R07 N06 N07 2.97e-01
C08 N07 N08 8.56e-09
L08 N07 N08 3.20e-11
R08 N07 N08 4.24e-01
C09 N08 N09 1.30e-08
L09 N08 N09 9.56e-12
R09 N08 N09 7.44e-02
C10 N09 N10 9.40e-09
L10 N09 N10 8.19e-12
R10 N09 N10 9.49e-02
C11 N10 N11 3.90e-11
L11 N10 N11 9.00e-12
R11 N10 N11 1.33e+00
C12 N11 Port2 6.65e-13
L12 N11 Port2 3.41e-10
R12 N11 Port2 1.00e+05
.ENDS GRM2195C1H562JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GRM2195C1H682JA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C1H682JA01 Port1 Port2
C01 Port1 N01 6.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.48e-11
R03 N02 N03 7.15e-03
L04 N03 N04 6.63e-11
R04 N03 N04 3.89e-01
L05 N04 N05 1.06e-10
R05 N04 N05 1.23e-02
C06 N05 N06 2.73e-08
L06 N05 N06 2.81e-11
R06 N05 N06 2.53e-01
C07 N06 N07 7.06e-09
L07 N06 N07 4.10e-11
R07 N06 N07 3.73e-01
C08 N07 N08 5.35e-09
L08 N07 N08 1.65e-11
R08 N07 N08 1.20e-01
C09 N08 N09 1.26e-10
L09 N08 N09 3.72e-12
R09 N08 N09 2.11e-01
C10 N09 Port2 7.35e-13
L10 N09 Port2 3.41e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2195C1H682JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GRM2195C1H822JA01
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C1H822JA01 Port1 Port2
C01 Port1 N01 8.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.89e-10
R03 N02 N03 6.14e-03
L04 N03 N04 1.45e-11
R04 N03 N04 4.64e-01
L05 N04 N05 8.80e-11
R05 N04 N05 2.41e-01
L06 N05 N06 8.20e-11
R06 N05 N06 8.61e-03
L07 N06 N07 1.33e-10
R07 N06 N07 1.51e-03
C08 N07 N08 3.63e-08
L08 N07 N08 2.60e-11
R08 N07 N08 2.02e-01
C09 N08 N09 1.07e-08
L09 N08 N09 3.61e-11
R09 N08 N09 2.80e-01
C10 N09 N10 4.29e-11
L10 N09 N10 7.76e-12
R10 N09 N10 2.14e+00
C11 N10 Port2 5.59e-12
L11 N10 Port2 5.40e-11
R11 N10 Port2 1.00e+05
.ENDS GRM2195C1H822JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRM2195C2A103JA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C2A103JA01 Port1 Port2
C01 Port1 N01 9.85e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 4.22e-03
L04 N03 N04 1.32e-10
R04 N03 N04 2.65e-01
L05 N04 N05 1.12e-10
R05 N04 N05 6.32e-03
C06 N05 N06 4.00e-08
L06 N05 N06 3.28e-11
R06 N05 N06 2.77e-01
C07 N06 N07 1.59e-08
L07 N06 N07 3.66e-11
R07 N06 N07 2.93e-01
C08 N07 N08 1.41e-07
L08 N07 N08 1.97e-12
R08 N07 N08 3.63e-02
C09 N08 N09 1.81e-08
L09 N08 N09 9.20e-12
R09 N08 N09 8.88e-02
C10 N09 N10 7.84e-11
L10 N09 N10 5.62e-12
R10 N09 N10 1.34e-01
C11 N10 Port2 2.36e-12
L11 N10 Port2 1.02e-10
R11 N10 Port2 1.00e+05
.ENDS GRM2195C2A103JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GRM2195C2A123JA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C2A123JA01 Port1 Port2
C01 Port1 N01 1.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 3.19e-03
L04 N03 N04 3.63e-11
R04 N03 N04 2.93e+00
L05 N04 N05 9.04e-11
R05 N04 N05 2.06e-01
L06 N05 N06 8.53e-11
R06 N05 N06 6.05e-03
L07 N06 N07 8.88e-09
R07 N06 N07 1.65e-03
C08 N07 N08 3.87e-08
L08 N07 N08 3.70e-11
R08 N07 N08 2.15e-01
C09 N08 N09 1.66e-08
L09 N08 N09 3.29e-11
R09 N08 N09 2.63e-01
C10 N09 Port2 2.23e-12
L10 N09 Port2 1.18e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2195C2A123JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GRM2195C2A153JA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C2A153JA01 Port1 Port2
C01 Port1 N01 1.48e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 3.71e-03
L04 N03 N04 1.16e-10
R04 N03 N04 2.25e-01
L05 N04 N05 6.62e-11
R05 N04 N05 3.94e-03
C06 N05 N06 4.31e-08
L06 N05 N06 4.49e-11
R06 N05 N06 2.01e-01
C07 N06 N07 1.81e-08
L07 N06 N07 4.62e-11
R07 N06 N07 2.85e-01
C08 N07 N08 6.88e-08
L08 N07 N08 5.61e-12
R08 N07 N08 5.25e-02
C09 N08 N09 3.11e-08
L09 N08 N09 7.68e-12
R09 N08 N09 1.09e-01
C10 N09 N10 5.85e-11
L10 N09 N10 8.02e-12
R10 N09 N10 2.87e-01
C11 N10 Port2 3.91e-12
L11 N10 Port2 6.67e-11
R11 N10 Port2 1.00e+05
.ENDS GRM2195C2A153JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-02[uF]/100[V]
* Murata P/N :GRM2195C2A273GE01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C2A273GE01 Port1 Port2
C01 Port1 N01 2.69e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.75e-10
R03 N02 N03 4.80e-03
L04 N03 N04 8.58e-12
R04 N03 N04 1.40e-01
L05 N04 N05 8.59e-11
R05 N04 N05 1.31e-01
L06 N05 N06 4.48e-11
R06 N05 N06 3.30e-03
L07 N06 N07 1.43e-10
R07 N06 N07 1.85e-03
C08 N07 N08 9.72e-08
L08 N07 N08 2.98e-11
R08 N07 N08 1.34e-01
C09 N08 N09 3.43e-08
L09 N08 N09 3.31e-11
R09 N08 N09 1.69e-01
C10 N09 N10 4.87e-07
L10 N09 N10 1.08e-12
R10 N09 N10 1.27e-02
C11 N10 Port2 5.12e-08
L11 N10 Port2 6.16e-12
R11 N10 Port2 3.62e-02
.ENDS GRM2195C2A273GE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-02[uF]/100[V]
* Murata P/N :GRM2195C2A273JE01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C2A273JE01 Port1 Port2
C01 Port1 N01 2.69e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.75e-10
R03 N02 N03 4.80e-03
L04 N03 N04 8.58e-12
R04 N03 N04 1.40e-01
L05 N04 N05 8.59e-11
R05 N04 N05 1.31e-01
L06 N05 N06 4.48e-11
R06 N05 N06 3.30e-03
L07 N06 N07 1.43e-10
R07 N06 N07 1.85e-03
C08 N07 N08 9.72e-08
L08 N07 N08 2.98e-11
R08 N07 N08 1.34e-01
C09 N08 N09 3.43e-08
L09 N08 N09 3.31e-11
R09 N08 N09 1.69e-01
C10 N09 N10 4.87e-07
L10 N09 N10 1.08e-12
R10 N09 N10 1.27e-02
C11 N10 Port2 5.12e-08
L11 N10 Port2 6.16e-12
R11 N10 Port2 3.62e-02
.ENDS GRM2195C2A273JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-02[uF]/100[V]
* Murata P/N :GRM2195C2A333GE01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C2A333GE01 Port1 Port2
C01 Port1 N01 3.29e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.35e-10
R03 N02 N03 3.96e-03
L04 N03 N04 6.78e-12
R04 N03 N04 1.43e-01
L05 N04 N05 6.95e-11
R05 N04 N05 1.08e-01
L06 N05 N06 2.18e-11
R06 N05 N06 2.68e-02
L07 N06 N07 5.37e-11
R07 N06 N07 2.90e-03
L08 N07 N08 1.54e-10
R08 N07 N08 1.48e-03
C09 N08 N09 1.05e-07
L09 N08 N09 3.71e-11
R09 N08 N09 1.56e-01
C10 N09 N10 4.19e-08
L10 N09 N10 3.82e-11
R10 N09 N10 1.83e-01
C11 N10 N11 3.57e-07
L11 N10 N11 2.15e-12
R11 N10 N11 2.16e-02
C12 N11 Port2 4.14e-08
L12 N11 Port2 1.12e-11
R12 N11 Port2 4.51e-02
.ENDS GRM2195C2A333GE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-02[uF]/100[V]
* Murata P/N :GRM2195C2A333JE01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C2A333JE01 Port1 Port2
C01 Port1 N01 3.29e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.35e-10
R03 N02 N03 3.96e-03
L04 N03 N04 6.78e-12
R04 N03 N04 1.43e-01
L05 N04 N05 6.95e-11
R05 N04 N05 1.08e-01
L06 N05 N06 2.18e-11
R06 N05 N06 2.68e-02
L07 N06 N07 5.37e-11
R07 N06 N07 2.90e-03
L08 N07 N08 1.54e-10
R08 N07 N08 1.48e-03
C09 N08 N09 1.05e-07
L09 N08 N09 3.71e-11
R09 N08 N09 1.56e-01
C10 N09 N10 4.19e-08
L10 N09 N10 3.82e-11
R10 N09 N10 1.83e-01
C11 N10 N11 3.57e-07
L11 N10 N11 2.15e-12
R11 N10 N11 2.16e-02
C12 N11 Port2 4.14e-08
L12 N11 Port2 1.12e-11
R12 N11 Port2 4.51e-02
.ENDS GRM2195C2A333JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-02[uF]/100[V]
* Murata P/N :GRM2195C2A393GE01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C2A393GE01 Port1 Port2
C01 Port1 N01 3.86e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.91e-10
R03 N02 N03 3.55e-03
L04 N03 N04 8.13e-12
R04 N03 N04 1.52e-01
L05 N04 N05 7.47e-11
R05 N04 N05 1.10e-01
L06 N05 N06 2.18e-11
R06 N05 N06 2.65e-02
L07 N06 N07 5.17e-11
R07 N06 N07 2.73e-03
L08 N07 N08 1.42e-10
R08 N07 N08 1.36e-03
C09 N08 N09 1.12e-07
L09 N08 N09 4.41e-11
R09 N08 N09 1.70e-01
C10 N09 N10 5.02e-08
L10 N09 N10 4.20e-11
R10 N09 N10 1.82e-01
C11 N10 N11 3.33e-07
L11 N10 N11 3.07e-12
R11 N10 N11 2.66e-02
C12 N11 Port2 3.36e-08
L12 N11 Port2 1.82e-11
R12 N11 Port2 5.03e-02
.ENDS GRM2195C2A393GE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-02[uF]/100[V]
* Murata P/N :GRM2195C2A393JE01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C2A393JE01 Port1 Port2
C01 Port1 N01 3.86e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.91e-10
R03 N02 N03 3.55e-03
L04 N03 N04 8.13e-12
R04 N03 N04 1.52e-01
L05 N04 N05 7.47e-11
R05 N04 N05 1.10e-01
L06 N05 N06 2.18e-11
R06 N05 N06 2.65e-02
L07 N06 N07 5.17e-11
R07 N06 N07 2.73e-03
L08 N07 N08 1.42e-10
R08 N07 N08 1.36e-03
C09 N08 N09 1.12e-07
L09 N08 N09 4.41e-11
R09 N08 N09 1.70e-01
C10 N09 N10 5.02e-08
L10 N09 N10 4.20e-11
R10 N09 N10 1.82e-01
C11 N10 N11 3.33e-07
L11 N10 N11 3.07e-12
R11 N10 N11 2.66e-02
C12 N11 Port2 3.36e-08
L12 N11 Port2 1.82e-11
R12 N11 Port2 5.03e-02
.ENDS GRM2195C2A393JE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GRM2195C2A562JA01
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C2A562JA01 Port1 Port2
C01 Port1 N01 5.70e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 4.66e-03
L04 N03 N04 1.04e-10
R04 N03 N04 3.42e-01
L05 N04 N05 8.94e-11
R05 N04 N05 7.30e-03
L06 N05 N06 6.66e-11
R06 N05 N06 1.34e-03
C07 N06 N07 1.63e-08
L07 N06 N07 4.04e-11
R07 N06 N07 2.97e-01
C08 N07 N08 8.56e-09
L08 N07 N08 3.20e-11
R08 N07 N08 4.24e-01
C09 N08 N09 1.30e-08
L09 N08 N09 9.56e-12
R09 N08 N09 7.44e-02
C10 N09 N10 9.40e-09
L10 N09 N10 8.19e-12
R10 N09 N10 9.49e-02
C11 N10 N11 3.90e-11
L11 N10 N11 9.00e-12
R11 N10 N11 1.33e+00
C12 N11 Port2 6.65e-13
L12 N11 Port2 3.41e-10
R12 N11 Port2 1.00e+05
.ENDS GRM2195C2A562JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GRM2195C2A682JA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C2A682JA01 Port1 Port2
C01 Port1 N01 6.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.48e-11
R03 N02 N03 7.15e-03
L04 N03 N04 6.63e-11
R04 N03 N04 3.89e-01
L05 N04 N05 1.06e-10
R05 N04 N05 1.23e-02
C06 N05 N06 2.73e-08
L06 N05 N06 2.81e-11
R06 N05 N06 2.53e-01
C07 N06 N07 7.06e-09
L07 N06 N07 4.10e-11
R07 N06 N07 3.73e-01
C08 N07 N08 5.35e-09
L08 N07 N08 1.65e-11
R08 N07 N08 1.20e-01
C09 N08 N09 1.26e-10
L09 N08 N09 3.72e-12
R09 N08 N09 2.11e-01
C10 N09 Port2 7.35e-13
L10 N09 Port2 3.41e-10
R10 N09 Port2 1.00e+05
.ENDS GRM2195C2A682JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GRM2195C2A822JA01
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2195C2A822JA01 Port1 Port2
C01 Port1 N01 8.16e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.89e-10
R03 N02 N03 6.14e-03
L04 N03 N04 1.45e-11
R04 N03 N04 4.64e-01
L05 N04 N05 8.80e-11
R05 N04 N05 2.41e-01
L06 N05 N06 8.20e-11
R06 N05 N06 8.61e-03
L07 N06 N07 1.33e-10
R07 N06 N07 1.51e-03
C08 N07 N08 3.63e-08
L08 N07 N08 2.60e-11
R08 N07 N08 2.02e-01
C09 N08 N09 1.07e-08
L09 N08 N09 3.61e-11
R09 N08 N09 2.80e-01
C10 N09 N10 4.29e-11
L10 N09 N10 7.76e-12
R10 N09 N10 2.14e+00
C11 N10 Port2 5.59e-12
L11 N10 Port2 5.40e-11
R11 N10 Port2 1.00e+05
.ENDS GRM2195C2A822JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/3.90e-02[uF]/10[V]
* Murata P/N :GRM2197U1A393JA01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2197U1A393JA01 Port1 Port2
C01 Port1 N01 3.81e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 7.69e-11
R03 N02 N03 5.34e-03
L04 N03 N04 9.52e-11
R04 N03 N04 1.27e-01
L05 N04 N05 7.81e-11
R05 N04 N05 6.86e-03
C06 N05 N06 1.51e-07
L06 N05 N06 3.10e-11
R06 N05 N06 8.00e-02
C07 N06 N07 4.71e-08
L07 N06 N07 3.83e-11
R07 N06 N07 1.17e-01
C08 N07 N08 5.30e-08
L08 N07 N08 1.16e-11
R08 N07 N08 3.26e-02
C09 N08 Port2 8.61e-13
L09 N08 Port2 3.23e-10
R09 N08 Port2 4.35e+02
.ENDS GRM2197U1A393JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/4.70e-02[uF]/10[V]
* Murata P/N :GRM2197U1A473JA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2197U1A473JA01 Port1 Port2
C01 Port1 N01 4.59e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 9.77e-12
R03 N02 N03 5.10e-03
L04 N03 N04 1.99e-11
R04 N03 N04 7.20e-01
L05 N04 N05 6.65e-11
R05 N04 N05 1.60e-01
L06 N05 N06 8.81e-11
R06 N05 N06 4.56e-03
C07 N06 N07 2.18e-07
L07 N06 N07 2.75e-11
R07 N06 N07 8.79e-02
C08 N07 N08 5.22e-08
L08 N07 N08 4.85e-11
R08 N07 N08 1.44e-01
C09 N08 N09 1.23e-08
L09 N08 N09 5.80e-11
R09 N08 N09 7.27e-02
C10 N09 N10 1.26e-11
L10 N09 N10 2.79e-11
R10 N09 N10 1.23e+01
C11 N10 Port2 9.95e-13
L11 N10 Port2 3.10e-10
R11 N10 Port2 1.00e+05
.ENDS GRM2197U1A473JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/5.60e-02[uF]/10[V]
* Murata P/N :GRM2197U1A563JA01
* Property : C = 5.60e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2197U1A563JA01 Port1 Port2
C01 Port1 N01 5.52e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 2.27e-10
R03 N02 N03 4.73e-03
L04 N03 N04 1.59e-11
R04 N03 N04 1.60e-01
L05 N04 N05 1.14e-10
R05 N04 N05 1.07e-01
L06 N05 N06 7.29e-11
R06 N05 N06 2.76e-03
C07 N06 N07 2.18e-07
L07 N06 N07 3.45e-11
R07 N06 N07 9.08e-02
C08 N07 N08 6.67e-08
L08 N07 N08 4.96e-11
R08 N07 N08 1.20e-01
C09 N08 Port2 4.31e-12
L09 N08 Port2 7.80e-11
R09 N08 Port2 4.11e+01
.ENDS GRM2197U1A563JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRM2197U1H223JA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2197U1H223JA01 Port1 Port2
C01 Port1 N01 2.10e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.11e-12
R03 N02 N03 5.50e-03
L04 N03 N04 2.04e-11
R04 N03 N04 4.41e-01
L05 N04 N05 1.68e-10
R05 N04 N05 1.54e-01
L06 N05 N06 2.05e-10
R06 N05 N06 2.56e-03
C07 N06 N07 1.43e-07
L07 N06 N07 1.77e-11
R07 N06 N07 1.04e-01
C08 N07 N08 4.31e-08
L08 N07 N08 2.29e-11
R08 N07 N08 1.36e-01
C09 N08 N09 9.75e-12
L09 N08 N09 3.60e-11
R09 N08 N09 1.58e+01
C10 N09 Port2 1.02e-12
L10 N09 Port2 3.16e-10
R10 N09 Port2 7.29e+02
.ENDS GRM2197U1H223JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GRM2197U1H273JA01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM2197U1H273JA01 Port1 Port2
C01 Port1 N01 2.66e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 5.64e-03
L04 N03 N04 3.55e-11
R04 N03 N04 2.02e+00
L05 N04 N05 6.94e-11
R05 N04 N05 1.68e-01
L06 N05 N06 9.97e-11
R06 N05 N06 5.48e-03
C07 N06 N07 1.20e-07
L07 N06 N07 2.72e-11
R07 N06 N07 1.07e-01
C08 N07 N08 3.37e-08
L08 N07 N08 4.25e-11
R08 N07 N08 1.39e-01
C09 N08 N09 1.20e-08
L09 N08 N09 3.62e-11
R09 N08 N09 7.56e-02
C10 N09 N10 2.65e-11
L10 N09 N10 1.32e-11
R10 N09 N10 5.83e+00
C11 N10 Port2 1.05e-12
L11 N10 Port2 2.81e-10
R11 N10 Port2 1.00e+05
.ENDS GRM2197U1H273JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GRM21A1X1H333JA39
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A1X1H333JA39 Port1 Port2
C01 Port1 N01 3.22e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 3.42e-03
L04 N03 N04 1.81e-11
R04 N03 N04 4.91e-01
L05 N04 N05 1.60e-10
R05 N04 N05 1.75e-01
L06 N05 N06 1.32e-10
R06 N05 N06 2.86e-03
C07 N06 N07 1.14e-07
L07 N06 N07 3.95e-11
R07 N06 N07 1.69e-01
C08 N07 N08 7.52e-08
L08 N07 N08 2.79e-11
R08 N07 N08 1.45e-01
C09 N08 N09 1.71e-07
L09 N08 N09 5.36e-12
R09 N08 N09 2.49e-02
C10 N09 N10 1.63e-07
L10 N09 N10 3.74e-12
R10 N09 N10 3.70e-02
C11 N10 N11 1.06e-11
L11 N10 N11 3.32e-11
R11 N10 N11 8.90e+00
C12 N11 Port2 1.04e-12
L12 N11 Port2 2.53e-10
R12 N11 Port2 1.00e+05
.ENDS GRM21A1X1H333JA39
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GRM21A3U1H333JA39
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A3U1H333JA39 Port1 Port2
C01 Port1 N01 3.22e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 3.42e-03
L04 N03 N04 1.81e-11
R04 N03 N04 4.91e-01
L05 N04 N05 1.60e-10
R05 N04 N05 1.75e-01
L06 N05 N06 1.32e-10
R06 N05 N06 2.86e-03
C07 N06 N07 1.14e-07
L07 N06 N07 3.95e-11
R07 N06 N07 1.69e-01
C08 N07 N08 7.52e-08
L08 N07 N08 2.79e-11
R08 N07 N08 1.45e-01
C09 N08 N09 1.71e-07
L09 N08 N09 5.36e-12
R09 N08 N09 2.49e-02
C10 N09 N10 1.63e-07
L10 N09 N10 3.74e-12
R10 N09 N10 3.70e-02
C11 N10 N11 1.06e-11
L11 N10 N11 3.32e-11
R11 N10 N11 8.90e+00
C12 N11 Port2 1.04e-12
L12 N11 Port2 2.53e-10
R12 N11 Port2 1.00e+05
.ENDS GRM21A3U1H333JA39
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E100FW01
* Property : C = 1.00e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E100FW01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.27e-11
R03 N02 N03 3.44e-01
C04 N03 N04 1.88e-09
L04 N03 N04 1.35e-12
R04 N03 N04 6.56e-02
C05 N04 N05 1.06e-10
L05 N04 N05 8.74e-12
R05 N04 N05 3.61e+00
C06 N05 N06 8.85e-13
L06 N05 N06 4.88e-10
R06 N05 N06 2.57e+02
C07 N06 Port2 4.54e-12
L07 N06 Port2 7.56e-11
R07 N06 Port2 7.67e+01
.ENDS GRM21A5C2E100FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E100GW01
* Property : C = 1.00e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E100GW01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.27e-11
R03 N02 N03 3.44e-01
C04 N03 N04 1.88e-09
L04 N03 N04 1.35e-12
R04 N03 N04 6.56e-02
C05 N04 N05 1.06e-10
L05 N04 N05 8.74e-12
R05 N04 N05 3.61e+00
C06 N05 N06 8.85e-13
L06 N05 N06 4.88e-10
R06 N05 N06 2.57e+02
C07 N06 Port2 4.54e-12
L07 N06 Port2 7.56e-11
R07 N06 Port2 7.67e+01
.ENDS GRM21A5C2E100GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E100JW01
* Property : C = 1.00e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E100JW01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.27e-11
R03 N02 N03 3.44e-01
C04 N03 N04 1.88e-09
L04 N03 N04 1.35e-12
R04 N03 N04 6.56e-02
C05 N04 N05 1.06e-10
L05 N04 N05 8.74e-12
R05 N04 N05 3.61e+00
C06 N05 N06 8.85e-13
L06 N05 N06 4.88e-10
R06 N05 N06 2.57e+02
C07 N06 Port2 4.54e-12
L07 N06 Port2 7.56e-11
R07 N06 Port2 7.67e+01
.ENDS GRM21A5C2E100JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E101FW01
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E101FW01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-11
R03 N02 N03 1.43e-01
C04 N03 N04 1.50e-09
L04 N03 N04 8.14e-12
R04 N03 N04 4.60e-01
C05 N04 N05 1.20e-10
L05 N04 N05 4.05e-11
R05 N04 N05 2.54e+00
C06 N05 Port2 7.11e-13
L06 N05 Port2 5.93e-10
R06 N05 Port2 2.22e+02
.ENDS GRM21A5C2E101FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E101GW01
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E101GW01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-11
R03 N02 N03 1.43e-01
C04 N03 N04 1.50e-09
L04 N03 N04 8.14e-12
R04 N03 N04 4.60e-01
C05 N04 N05 1.20e-10
L05 N04 N05 4.05e-11
R05 N04 N05 2.54e+00
C06 N05 Port2 7.11e-13
L06 N05 Port2 5.93e-10
R06 N05 Port2 2.22e+02
.ENDS GRM21A5C2E101GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E101JW01
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E101JW01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-11
R03 N02 N03 1.43e-01
C04 N03 N04 1.50e-09
L04 N03 N04 8.14e-12
R04 N03 N04 4.60e-01
C05 N04 N05 1.20e-10
L05 N04 N05 4.05e-11
R05 N04 N05 2.54e+00
C06 N05 Port2 7.11e-13
L06 N05 Port2 5.93e-10
R06 N05 Port2 2.22e+02
.ENDS GRM21A5C2E101JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E102FWA1
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E102FWA1 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 1.29e-02
C04 N03 N04 2.29e-08
R04 N03 N04 1.43e+02
L05 N04 N05 8.75e-11
R05 N04 N05 1.15e+00
L06 N05 N06 8.93e-11
R06 N05 N06 2.97e-02
C07 N06 N07 9.09e-09
L07 N06 N07 1.04e-11
R07 N06 N07 2.90e-01
C08 N07 N08 1.28e-09
L08 N07 N08 2.84e-11
R08 N07 N08 6.75e-01
C09 N08 N09 3.18e-09
L09 N08 N09 2.94e-12
R09 N08 N09 9.54e-02
C10 N09 Port2 9.82e-13
L10 N09 Port2 2.83e-10
R10 N09 Port2 2.55e+02
.ENDS GRM21A5C2E102FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E102GWA1
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E102GWA1 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 1.29e-02
C04 N03 N04 2.29e-08
R04 N03 N04 1.43e+02
L05 N04 N05 8.75e-11
R05 N04 N05 1.15e+00
L06 N05 N06 8.93e-11
R06 N05 N06 2.97e-02
C07 N06 N07 9.09e-09
L07 N06 N07 1.04e-11
R07 N06 N07 2.90e-01
C08 N07 N08 1.28e-09
L08 N07 N08 2.84e-11
R08 N07 N08 6.75e-01
C09 N08 N09 3.18e-09
L09 N08 N09 2.94e-12
R09 N08 N09 9.54e-02
C10 N09 Port2 9.82e-13
L10 N09 Port2 2.83e-10
R10 N09 Port2 2.55e+02
.ENDS GRM21A5C2E102GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E102JWA1
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E102JWA1 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 1.29e-02
C04 N03 N04 2.29e-08
R04 N03 N04 1.43e+02
L05 N04 N05 8.75e-11
R05 N04 N05 1.15e+00
L06 N05 N06 8.93e-11
R06 N05 N06 2.97e-02
C07 N06 N07 9.09e-09
L07 N06 N07 1.04e-11
R07 N06 N07 2.90e-01
C08 N07 N08 1.28e-09
L08 N07 N08 2.84e-11
R08 N07 N08 6.75e-01
C09 N08 N09 3.18e-09
L09 N08 N09 2.94e-12
R09 N08 N09 9.54e-02
C10 N09 Port2 9.82e-13
L10 N09 Port2 2.83e-10
R10 N09 Port2 2.55e+02
.ENDS GRM21A5C2E102JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E120FW01
* Property : C = 1.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E120FW01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.22e-12
R03 N02 N03 2.17e-01
C04 N03 N04 1.66e-09
L04 N03 N04 1.68e-12
R04 N03 N04 8.76e-02
C05 N04 N05 9.31e-11
L05 N04 N05 1.36e-11
R05 N04 N05 4.82e+00
C06 N05 N06 1.34e-12
L06 N05 N06 4.51e-10
R06 N05 N06 2.99e+02
C07 N06 Port2 2.83e-12
L07 N06 Port2 1.45e-10
R07 N06 Port2 1.06e+02
.ENDS GRM21A5C2E120FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E120GW01
* Property : C = 1.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E120GW01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.22e-12
R03 N02 N03 2.17e-01
C04 N03 N04 1.66e-09
L04 N03 N04 1.68e-12
R04 N03 N04 8.76e-02
C05 N04 N05 9.31e-11
L05 N04 N05 1.36e-11
R05 N04 N05 4.82e+00
C06 N05 N06 1.34e-12
L06 N05 N06 4.51e-10
R06 N05 N06 2.99e+02
C07 N06 Port2 2.83e-12
L07 N06 Port2 1.45e-10
R07 N06 Port2 1.06e+02
.ENDS GRM21A5C2E120GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E120JW01
* Property : C = 1.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E120JW01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.22e-12
R03 N02 N03 2.17e-01
C04 N03 N04 1.66e-09
L04 N03 N04 1.68e-12
R04 N03 N04 8.76e-02
C05 N04 N05 9.31e-11
L05 N04 N05 1.36e-11
R05 N04 N05 4.82e+00
C06 N05 N06 1.34e-12
L06 N05 N06 4.51e-10
R06 N05 N06 2.99e+02
C07 N06 Port2 2.83e-12
L07 N06 Port2 1.45e-10
R07 N06 Port2 1.06e+02
.ENDS GRM21A5C2E120JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E121FW01
* Property : C = 1.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E121FW01 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.45e-11
R03 N02 N03 9.57e-02
C04 N03 N04 8.53e-10
L04 N03 N04 7.27e-12
R04 N03 N04 6.04e-01
C05 N04 N05 8.24e-11
L05 N04 N05 2.37e-11
R05 N04 N05 2.29e+00
C06 N05 Port2 6.34e-13
L06 N05 Port2 4.82e-10
R06 N05 Port2 2.61e+02
.ENDS GRM21A5C2E121FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E121GW01
* Property : C = 1.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E121GW01 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.45e-11
R03 N02 N03 9.57e-02
C04 N03 N04 8.53e-10
L04 N03 N04 7.27e-12
R04 N03 N04 6.04e-01
C05 N04 N05 8.24e-11
L05 N04 N05 2.37e-11
R05 N04 N05 2.29e+00
C06 N05 Port2 6.34e-13
L06 N05 Port2 4.82e-10
R06 N05 Port2 2.61e+02
.ENDS GRM21A5C2E121GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E121JW01
* Property : C = 1.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E121JW01 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.45e-11
R03 N02 N03 9.57e-02
C04 N03 N04 8.53e-10
L04 N03 N04 7.27e-12
R04 N03 N04 6.04e-01
C05 N04 N05 8.24e-11
L05 N04 N05 2.37e-11
R05 N04 N05 2.29e+00
C06 N05 Port2 6.34e-13
L06 N05 Port2 4.82e-10
R06 N05 Port2 2.61e+02
.ENDS GRM21A5C2E121JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E122FWA1
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E122FWA1 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.75e-11
R03 N02 N03 1.51e-02
C04 N03 N04 2.71e-08
R04 N03 N04 1.40e+02
L05 N04 N05 8.35e-11
R05 N04 N05 1.40e+00
L06 N05 N06 7.95e-11
R06 N05 N06 2.37e-02
C07 N06 N07 7.55e-09
L07 N06 N07 1.61e-11
R07 N06 N07 3.16e-01
C08 N07 N08 1.50e-09
L08 N07 N08 3.19e-11
R08 N07 N08 6.90e-01
C09 N08 N09 1.07e-09
L09 N08 N09 1.29e-11
R09 N08 N09 2.18e-01
C10 N09 Port2 6.83e-13
L10 N09 Port2 3.55e-10
R10 N09 Port2 3.42e+02
.ENDS GRM21A5C2E122FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E122GWA1
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E122GWA1 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.75e-11
R03 N02 N03 1.51e-02
C04 N03 N04 2.71e-08
R04 N03 N04 1.40e+02
L05 N04 N05 8.35e-11
R05 N04 N05 1.40e+00
L06 N05 N06 7.95e-11
R06 N05 N06 2.37e-02
C07 N06 N07 7.55e-09
L07 N06 N07 1.61e-11
R07 N06 N07 3.16e-01
C08 N07 N08 1.50e-09
L08 N07 N08 3.19e-11
R08 N07 N08 6.90e-01
C09 N08 N09 1.07e-09
L09 N08 N09 1.29e-11
R09 N08 N09 2.18e-01
C10 N09 Port2 6.83e-13
L10 N09 Port2 3.55e-10
R10 N09 Port2 3.42e+02
.ENDS GRM21A5C2E122GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E122JWA1
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E122JWA1 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.75e-11
R03 N02 N03 1.51e-02
C04 N03 N04 2.71e-08
R04 N03 N04 1.40e+02
L05 N04 N05 8.35e-11
R05 N04 N05 1.40e+00
L06 N05 N06 7.95e-11
R06 N05 N06 2.37e-02
C07 N06 N07 7.55e-09
L07 N06 N07 1.61e-11
R07 N06 N07 3.16e-01
C08 N07 N08 1.50e-09
L08 N07 N08 3.19e-11
R08 N07 N08 6.90e-01
C09 N08 N09 1.07e-09
L09 N08 N09 1.29e-11
R09 N08 N09 2.18e-01
C10 N09 Port2 6.83e-13
L10 N09 Port2 3.55e-10
R10 N09 Port2 3.42e+02
.ENDS GRM21A5C2E122JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E150FW01
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E150FW01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.53e-12
R03 N02 N03 2.03e-01
C04 N03 N04 2.45e-09
L04 N03 N04 1.11e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.41e-10
L05 N04 N05 1.19e-11
R05 N04 N05 3.66e+00
C06 N05 N06 4.68e-12
L06 N05 N06 1.58e-10
R06 N05 N06 5.96e+01
C07 N06 Port2 1.00e-12
L07 N06 Port2 4.10e-10
R07 N06 Port2 4.63e+02
.ENDS GRM21A5C2E150FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E150GW01
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E150GW01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.53e-12
R03 N02 N03 2.03e-01
C04 N03 N04 2.45e-09
L04 N03 N04 1.11e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.41e-10
L05 N04 N05 1.19e-11
R05 N04 N05 3.66e+00
C06 N05 N06 4.68e-12
L06 N05 N06 1.58e-10
R06 N05 N06 5.96e+01
C07 N06 Port2 1.00e-12
L07 N06 Port2 4.10e-10
R07 N06 Port2 4.63e+02
.ENDS GRM21A5C2E150GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E150JW01
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E150JW01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.53e-12
R03 N02 N03 2.03e-01
C04 N03 N04 2.45e-09
L04 N03 N04 1.11e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.41e-10
L05 N04 N05 1.19e-11
R05 N04 N05 3.66e+00
C06 N05 N06 4.68e-12
L06 N05 N06 1.58e-10
R06 N05 N06 5.96e+01
C07 N06 Port2 1.00e-12
L07 N06 Port2 4.10e-10
R07 N06 Port2 4.63e+02
.ENDS GRM21A5C2E150JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E151FW01
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E151FW01 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.51e-11
R03 N02 N03 9.18e-02
C04 N03 N04 9.39e-10
L04 N03 N04 9.77e-12
R04 N03 N04 6.77e-01
C05 N04 N05 1.36e-10
L05 N04 N05 2.24e-11
R05 N04 N05 2.41e+00
C06 N05 Port2 7.48e-13
L06 N05 Port2 4.50e-10
R06 N05 Port2 1.68e+02
.ENDS GRM21A5C2E151FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E151GW01
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E151GW01 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.51e-11
R03 N02 N03 9.18e-02
C04 N03 N04 9.39e-10
L04 N03 N04 9.77e-12
R04 N03 N04 6.77e-01
C05 N04 N05 1.36e-10
L05 N04 N05 2.24e-11
R05 N04 N05 2.41e+00
C06 N05 Port2 7.48e-13
L06 N05 Port2 4.50e-10
R06 N05 Port2 1.68e+02
.ENDS GRM21A5C2E151GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E151JW01
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E151JW01 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.51e-11
R03 N02 N03 9.18e-02
C04 N03 N04 9.39e-10
L04 N03 N04 9.77e-12
R04 N03 N04 6.77e-01
C05 N04 N05 1.36e-10
L05 N04 N05 2.24e-11
R05 N04 N05 2.41e+00
C06 N05 Port2 7.48e-13
L06 N05 Port2 4.50e-10
R06 N05 Port2 1.68e+02
.ENDS GRM21A5C2E151JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E152FWA1
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E152FWA1 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.18e-10
R03 N02 N03 1.98e-02
C04 N03 N04 4.32e-08
R04 N03 N04 7.60e+01
L05 N04 N05 9.18e-11
R05 N04 N05 2.85e-02
C06 N05 N06 2.48e-08
L06 N05 N06 4.68e-12
R06 N05 N06 1.01e-01
C07 N06 N07 2.14e-09
L07 N06 N07 2.01e-11
R07 N06 N07 3.75e-01
C08 N07 N08 7.64e-11
L08 N07 N08 5.42e-11
R08 N07 N08 3.88e-01
C09 N08 Port2 6.87e-13
L09 N08 Port2 4.05e-10
R09 N08 Port2 3.04e+02
.ENDS GRM21A5C2E152FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E152GWA1
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E152GWA1 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.18e-10
R03 N02 N03 1.98e-02
C04 N03 N04 4.32e-08
R04 N03 N04 7.60e+01
L05 N04 N05 9.18e-11
R05 N04 N05 2.85e-02
C06 N05 N06 2.48e-08
L06 N05 N06 4.68e-12
R06 N05 N06 1.01e-01
C07 N06 N07 2.14e-09
L07 N06 N07 2.01e-11
R07 N06 N07 3.75e-01
C08 N07 N08 7.64e-11
L08 N07 N08 5.42e-11
R08 N07 N08 3.88e-01
C09 N08 Port2 6.87e-13
L09 N08 Port2 4.05e-10
R09 N08 Port2 3.04e+02
.ENDS GRM21A5C2E152GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E152JWA1
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E152JWA1 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.18e-10
R03 N02 N03 1.98e-02
C04 N03 N04 4.32e-08
R04 N03 N04 7.60e+01
L05 N04 N05 9.18e-11
R05 N04 N05 2.85e-02
C06 N05 N06 2.48e-08
L06 N05 N06 4.68e-12
R06 N05 N06 1.01e-01
C07 N06 N07 2.14e-09
L07 N06 N07 2.01e-11
R07 N06 N07 3.75e-01
C08 N07 N08 7.64e-11
L08 N07 N08 5.42e-11
R08 N07 N08 3.88e-01
C09 N08 Port2 6.87e-13
L09 N08 Port2 4.05e-10
R09 N08 Port2 3.04e+02
.ENDS GRM21A5C2E152JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E180FW01
* Property : C = 1.80e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E180FW01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.11e-11
R03 N02 N03 2.14e-01
C04 N03 N04 1.55e-09
L04 N03 N04 1.76e-12
R04 N03 N04 1.79e-01
C05 N04 N05 2.27e-10
L05 N04 N05 7.59e-12
R05 N04 N05 1.83e+00
C06 N05 N06 4.47e-12
L06 N05 N06 1.50e-10
R06 N05 N06 4.73e+01
C07 N06 Port2 8.74e-13
L07 N06 Port2 4.71e-10
R07 N06 Port2 4.23e+02
.ENDS GRM21A5C2E180FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E180GW01
* Property : C = 1.80e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E180GW01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.11e-11
R03 N02 N03 2.14e-01
C04 N03 N04 1.55e-09
L04 N03 N04 1.76e-12
R04 N03 N04 1.79e-01
C05 N04 N05 2.27e-10
L05 N04 N05 7.59e-12
R05 N04 N05 1.83e+00
C06 N05 N06 4.47e-12
L06 N05 N06 1.50e-10
R06 N05 N06 4.73e+01
C07 N06 Port2 8.74e-13
L07 N06 Port2 4.71e-10
R07 N06 Port2 4.23e+02
.ENDS GRM21A5C2E180GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E180JW01
* Property : C = 1.80e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E180JW01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.11e-11
R03 N02 N03 2.14e-01
C04 N03 N04 1.55e-09
L04 N03 N04 1.76e-12
R04 N03 N04 1.79e-01
C05 N04 N05 2.27e-10
L05 N04 N05 7.59e-12
R05 N04 N05 1.83e+00
C06 N05 N06 4.47e-12
L06 N05 N06 1.50e-10
R06 N05 N06 4.73e+01
C07 N06 Port2 8.74e-13
L07 N06 Port2 4.71e-10
R07 N06 Port2 4.23e+02
.ENDS GRM21A5C2E180JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E181FW01
* Property : C = 1.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E181FW01 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-11
R03 N02 N03 8.78e-02
C04 N03 N04 1.03e-09
L04 N03 N04 1.22e-11
R04 N03 N04 8.66e-01
C05 N04 N05 1.54e-10
L05 N04 N05 2.76e-11
R05 N04 N05 2.09e+00
C06 N05 Port2 7.45e-13
L06 N05 Port2 4.53e-10
R06 N05 Port2 2.10e+02
.ENDS GRM21A5C2E181FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E181GW01
* Property : C = 1.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E181GW01 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-11
R03 N02 N03 8.78e-02
C04 N03 N04 1.03e-09
L04 N03 N04 1.22e-11
R04 N03 N04 8.66e-01
C05 N04 N05 1.54e-10
L05 N04 N05 2.76e-11
R05 N04 N05 2.09e+00
C06 N05 Port2 7.45e-13
L06 N05 Port2 4.53e-10
R06 N05 Port2 2.10e+02
.ENDS GRM21A5C2E181GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E181JW01
* Property : C = 1.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E181JW01 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-11
R03 N02 N03 8.78e-02
C04 N03 N04 1.03e-09
L04 N03 N04 1.22e-11
R04 N03 N04 8.66e-01
C05 N04 N05 1.54e-10
L05 N04 N05 2.76e-11
R05 N04 N05 2.09e+00
C06 N05 Port2 7.45e-13
L06 N05 Port2 4.53e-10
R06 N05 Port2 2.10e+02
.ENDS GRM21A5C2E181JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E182FWA1
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E182FWA1 Port1 Port2
C01 Port1 N01 1.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.24e-10
R03 N02 N03 2.13e-02
C04 N03 N04 3.05e-08
R04 N03 N04 2.02e+02
L05 N04 N05 7.18e-11
R05 N04 N05 4.21e-01
L06 N05 N06 7.20e-11
R06 N05 N06 2.21e-02
C07 N06 N07 2.67e-08
L07 N06 N07 5.88e-12
R07 N06 N07 1.22e-01
C08 N07 N08 2.61e-09
L08 N07 N08 2.31e-11
R08 N07 N08 4.07e-01
C09 N08 Port2 4.73e-12
L09 N08 Port2 6.99e-11
R09 N08 Port2 1.68e+01
.ENDS GRM21A5C2E182FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E182GWA1
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E182GWA1 Port1 Port2
C01 Port1 N01 1.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.24e-10
R03 N02 N03 2.13e-02
C04 N03 N04 3.05e-08
R04 N03 N04 2.02e+02
L05 N04 N05 7.18e-11
R05 N04 N05 4.21e-01
L06 N05 N06 7.20e-11
R06 N05 N06 2.21e-02
C07 N06 N07 2.67e-08
L07 N06 N07 5.88e-12
R07 N06 N07 1.22e-01
C08 N07 N08 2.61e-09
L08 N07 N08 2.31e-11
R08 N07 N08 4.07e-01
C09 N08 Port2 4.73e-12
L09 N08 Port2 6.99e-11
R09 N08 Port2 1.68e+01
.ENDS GRM21A5C2E182GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E182JWA1
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E182JWA1 Port1 Port2
C01 Port1 N01 1.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.24e-10
R03 N02 N03 2.13e-02
C04 N03 N04 3.05e-08
R04 N03 N04 2.02e+02
L05 N04 N05 7.18e-11
R05 N04 N05 4.21e-01
L06 N05 N06 7.20e-11
R06 N05 N06 2.21e-02
C07 N06 N07 2.67e-08
L07 N06 N07 5.88e-12
R07 N06 N07 1.22e-01
C08 N07 N08 2.61e-09
L08 N07 N08 2.31e-11
R08 N07 N08 4.07e-01
C09 N08 Port2 4.73e-12
L09 N08 Port2 6.99e-11
R09 N08 Port2 1.68e+01
.ENDS GRM21A5C2E182JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E220FW01
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E220FW01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-11
R03 N02 N03 2.11e-01
C04 N03 N04 2.16e-10
L04 N03 N04 1.05e-11
R04 N03 N04 1.39e+00
C05 N04 N05 1.10e-11
L05 N04 N05 8.46e-11
R05 N04 N05 1.80e+01
C06 N05 Port2 8.16e-13
L06 N05 Port2 5.04e-10
R06 N05 Port2 3.21e+02
.ENDS GRM21A5C2E220FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E220GW01
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E220GW01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-11
R03 N02 N03 2.11e-01
C04 N03 N04 2.16e-10
L04 N03 N04 1.05e-11
R04 N03 N04 1.39e+00
C05 N04 N05 1.10e-11
L05 N04 N05 8.46e-11
R05 N04 N05 1.80e+01
C06 N05 Port2 8.16e-13
L06 N05 Port2 5.04e-10
R06 N05 Port2 3.21e+02
.ENDS GRM21A5C2E220GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E220JW01
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E220JW01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-11
R03 N02 N03 2.11e-01
C04 N03 N04 2.16e-10
L04 N03 N04 1.05e-11
R04 N03 N04 1.39e+00
C05 N04 N05 1.10e-11
L05 N04 N05 8.46e-11
R05 N04 N05 1.80e+01
C06 N05 Port2 8.16e-13
L06 N05 Port2 5.04e-10
R06 N05 Port2 3.21e+02
.ENDS GRM21A5C2E220JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E221FW01
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E221FW01 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 7.95e-02
C04 N03 N04 1.06e-09
L04 N03 N04 1.65e-11
R04 N03 N04 9.37e-01
C05 N04 N05 2.18e-10
L05 N04 N05 2.88e-11
R05 N04 N05 2.00e+00
C06 N05 N06 1.05e-09
L06 N05 N06 2.91e-12
R06 N05 N06 2.71e-01
C07 N06 N07 4.85e-10
L07 N06 N07 3.45e-12
R07 N06 N07 4.25e-01
C08 N07 Port2 1.01e-12
L08 N07 Port2 3.15e-10
R08 N07 Port2 8.32e+01
.ENDS GRM21A5C2E221FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E221GW01
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E221GW01 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 7.95e-02
C04 N03 N04 1.06e-09
L04 N03 N04 1.65e-11
R04 N03 N04 9.37e-01
C05 N04 N05 2.18e-10
L05 N04 N05 2.88e-11
R05 N04 N05 2.00e+00
C06 N05 N06 1.05e-09
L06 N05 N06 2.91e-12
R06 N05 N06 2.71e-01
C07 N06 N07 4.85e-10
L07 N06 N07 3.45e-12
R07 N06 N07 4.25e-01
C08 N07 Port2 1.01e-12
L08 N07 Port2 3.15e-10
R08 N07 Port2 8.32e+01
.ENDS GRM21A5C2E221GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E221JW01
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E221JW01 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 7.95e-02
C04 N03 N04 1.06e-09
L04 N03 N04 1.65e-11
R04 N03 N04 9.37e-01
C05 N04 N05 2.18e-10
L05 N04 N05 2.88e-11
R05 N04 N05 2.00e+00
C06 N05 N06 1.05e-09
L06 N05 N06 2.91e-12
R06 N05 N06 2.71e-01
C07 N06 N07 4.85e-10
L07 N06 N07 3.45e-12
R07 N06 N07 4.25e-01
C08 N07 Port2 1.01e-12
L08 N07 Port2 3.15e-10
R08 N07 Port2 8.32e+01
.ENDS GRM21A5C2E221JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E222FWA1
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E222FWA1 Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 1.45e-02
C04 N03 N04 6.67e-08
R04 N03 N04 6.77e+01
L05 N04 N05 5.50e-11
R05 N04 N05 5.61e-01
L06 N05 N06 7.35e-11
R06 N05 N06 2.58e-02
C07 N06 N07 1.87e-08
L07 N06 N07 1.18e-11
R07 N06 N07 1.74e-01
C08 N07 N08 2.86e-09
L08 N07 N08 2.99e-11
R08 N07 N08 4.70e-01
C09 N08 N09 1.22e-09
L09 N08 N09 1.81e-11
R09 N08 N09 1.72e-01
C10 N09 Port2 1.28e-12
L10 N09 Port2 2.18e-10
R10 N09 Port2 2.59e+02
.ENDS GRM21A5C2E222FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E222GWA1
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E222GWA1 Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 1.45e-02
C04 N03 N04 6.67e-08
R04 N03 N04 6.77e+01
L05 N04 N05 5.50e-11
R05 N04 N05 5.61e-01
L06 N05 N06 7.35e-11
R06 N05 N06 2.58e-02
C07 N06 N07 1.87e-08
L07 N06 N07 1.18e-11
R07 N06 N07 1.74e-01
C08 N07 N08 2.86e-09
L08 N07 N08 2.99e-11
R08 N07 N08 4.70e-01
C09 N08 N09 1.22e-09
L09 N08 N09 1.81e-11
R09 N08 N09 1.72e-01
C10 N09 Port2 1.28e-12
L10 N09 Port2 2.18e-10
R10 N09 Port2 2.59e+02
.ENDS GRM21A5C2E222GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E222JWA1
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E222JWA1 Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 1.45e-02
C04 N03 N04 6.67e-08
R04 N03 N04 6.77e+01
L05 N04 N05 5.50e-11
R05 N04 N05 5.61e-01
L06 N05 N06 7.35e-11
R06 N05 N06 2.58e-02
C07 N06 N07 1.87e-08
L07 N06 N07 1.18e-11
R07 N06 N07 1.74e-01
C08 N07 N08 2.86e-09
L08 N07 N08 2.99e-11
R08 N07 N08 4.70e-01
C09 N08 N09 1.22e-09
L09 N08 N09 1.81e-11
R09 N08 N09 1.72e-01
C10 N09 Port2 1.28e-12
L10 N09 Port2 2.18e-10
R10 N09 Port2 2.59e+02
.ENDS GRM21A5C2E222JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E270FW01
* Property : C = 2.70e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E270FW01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.08e-10
R03 N02 N03 1.91e-01
C04 N03 N04 2.72e-10
L04 N03 N04 1.15e-11
R04 N03 N04 1.92e+00
C05 N04 N05 2.04e-11
L05 N04 N05 6.27e-11
R05 N04 N05 1.11e+01
C06 N05 Port2 9.59e-13
L06 N05 Port2 4.29e-10
R06 N05 Port2 1.72e+02
.ENDS GRM21A5C2E270FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E270GW01
* Property : C = 2.70e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E270GW01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.08e-10
R03 N02 N03 1.91e-01
C04 N03 N04 2.72e-10
L04 N03 N04 1.15e-11
R04 N03 N04 1.92e+00
C05 N04 N05 2.04e-11
L05 N04 N05 6.27e-11
R05 N04 N05 1.11e+01
C06 N05 Port2 9.59e-13
L06 N05 Port2 4.29e-10
R06 N05 Port2 1.72e+02
.ENDS GRM21A5C2E270GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E270JW01
* Property : C = 2.70e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E270JW01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.08e-10
R03 N02 N03 1.91e-01
C04 N03 N04 2.72e-10
L04 N03 N04 1.15e-11
R04 N03 N04 1.92e+00
C05 N04 N05 2.04e-11
L05 N04 N05 6.27e-11
R05 N04 N05 1.11e+01
C06 N05 Port2 9.59e-13
L06 N05 Port2 4.29e-10
R06 N05 Port2 1.72e+02
.ENDS GRM21A5C2E270JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E271FW01
* Property : C = 2.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E271FW01 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.35e-10
R03 N02 N03 6.57e-02
C04 N03 N04 1.02e-09
L04 N03 N04 2.38e-11
R04 N03 N04 1.24e+00
C05 N04 N05 2.66e-10
L05 N04 N05 3.44e-11
R05 N04 N05 2.08e+00
C06 N05 N06 1.23e-09
L06 N05 N06 3.45e-12
R06 N05 N06 2.81e-01
C07 N06 N07 2.54e-10
L07 N06 N07 1.01e-11
R07 N06 N07 8.84e-01
C08 N07 Port2 1.21e-12
L08 N07 Port2 2.58e-10
R08 N07 Port2 5.99e+01
.ENDS GRM21A5C2E271FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E271GW01
* Property : C = 2.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E271GW01 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.35e-10
R03 N02 N03 6.57e-02
C04 N03 N04 1.02e-09
L04 N03 N04 2.38e-11
R04 N03 N04 1.24e+00
C05 N04 N05 2.66e-10
L05 N04 N05 3.44e-11
R05 N04 N05 2.08e+00
C06 N05 N06 1.23e-09
L06 N05 N06 3.45e-12
R06 N05 N06 2.81e-01
C07 N06 N07 2.54e-10
L07 N06 N07 1.01e-11
R07 N06 N07 8.84e-01
C08 N07 Port2 1.21e-12
L08 N07 Port2 2.58e-10
R08 N07 Port2 5.99e+01
.ENDS GRM21A5C2E271GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E271JW01
* Property : C = 2.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E271JW01 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.35e-10
R03 N02 N03 6.57e-02
C04 N03 N04 1.02e-09
L04 N03 N04 2.38e-11
R04 N03 N04 1.24e+00
C05 N04 N05 2.66e-10
L05 N04 N05 3.44e-11
R05 N04 N05 2.08e+00
C06 N05 N06 1.23e-09
L06 N05 N06 3.45e-12
R06 N05 N06 2.81e-01
C07 N06 N07 2.54e-10
L07 N06 N07 1.01e-11
R07 N06 N07 8.84e-01
C08 N07 Port2 1.21e-12
L08 N07 Port2 2.58e-10
R08 N07 Port2 5.99e+01
.ENDS GRM21A5C2E271JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E272FWA1
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E272FWA1 Port1 Port2
C01 Port1 N01 2.70e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.29e-10
R03 N02 N03 1.65e-02
C04 N03 N04 5.51e-08
R04 N03 N04 1.50e+02
L05 N04 N05 5.80e-11
R05 N04 N05 3.22e-01
L06 N05 N06 4.89e-11
R06 N05 N06 1.65e-02
C07 N06 N07 1.95e-08
L07 N06 N07 1.53e-11
R07 N06 N07 2.05e-01
C08 N07 N08 3.71e-09
L08 N07 N08 3.27e-11
R08 N07 N08 4.38e-01
C09 N08 N09 3.08e-09
L09 N08 N09 1.18e-11
R09 N08 N09 1.34e-01
C10 N09 N10 2.74e-11
L10 N09 N10 1.96e-11
R10 N09 N10 1.24e+01
C11 N10 N11 1.41e-11
L11 N10 N11 3.17e-11
R11 N10 N11 9.88e+00
C12 N11 Port2 5.00e-12
L12 N11 Port2 6.40e-11
R12 N11 Port2 3.06e+01
.ENDS GRM21A5C2E272FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E272GWA1
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E272GWA1 Port1 Port2
C01 Port1 N01 2.70e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.29e-10
R03 N02 N03 1.65e-02
C04 N03 N04 5.51e-08
R04 N03 N04 1.50e+02
L05 N04 N05 5.80e-11
R05 N04 N05 3.22e-01
L06 N05 N06 4.89e-11
R06 N05 N06 1.65e-02
C07 N06 N07 1.95e-08
L07 N06 N07 1.53e-11
R07 N06 N07 2.05e-01
C08 N07 N08 3.71e-09
L08 N07 N08 3.27e-11
R08 N07 N08 4.38e-01
C09 N08 N09 3.08e-09
L09 N08 N09 1.18e-11
R09 N08 N09 1.34e-01
C10 N09 N10 2.74e-11
L10 N09 N10 1.96e-11
R10 N09 N10 1.24e+01
C11 N10 N11 1.41e-11
L11 N10 N11 3.17e-11
R11 N10 N11 9.88e+00
C12 N11 Port2 5.00e-12
L12 N11 Port2 6.40e-11
R12 N11 Port2 3.06e+01
.ENDS GRM21A5C2E272GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-03[uF]/250[V]
* Murata P/N :GRM21A5C2E272JWA1
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E272JWA1 Port1 Port2
C01 Port1 N01 2.70e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.29e-10
R03 N02 N03 1.65e-02
C04 N03 N04 5.51e-08
R04 N03 N04 1.50e+02
L05 N04 N05 5.80e-11
R05 N04 N05 3.22e-01
L06 N05 N06 4.89e-11
R06 N05 N06 1.65e-02
C07 N06 N07 1.95e-08
L07 N06 N07 1.53e-11
R07 N06 N07 2.05e-01
C08 N07 N08 3.71e-09
L08 N07 N08 3.27e-11
R08 N07 N08 4.38e-01
C09 N08 N09 3.08e-09
L09 N08 N09 1.18e-11
R09 N08 N09 1.34e-01
C10 N09 N10 2.74e-11
L10 N09 N10 1.96e-11
R10 N09 N10 1.24e+01
C11 N10 N11 1.41e-11
L11 N10 N11 3.17e-11
R11 N10 N11 9.88e+00
C12 N11 Port2 5.00e-12
L12 N11 Port2 6.40e-11
R12 N11 Port2 3.06e+01
.ENDS GRM21A5C2E272JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E330FW01
* Property : C = 3.30e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E330FW01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.35e-11
R03 N02 N03 1.71e-01
C04 N03 N04 3.13e-10
L04 N03 N04 1.32e-11
R04 N03 N04 1.92e+00
C05 N04 N05 3.31e-11
L05 N04 N05 5.59e-11
R05 N04 N05 8.23e+00
C06 N05 Port2 8.74e-13
L06 N05 Port2 4.49e-10
R06 N05 Port2 1.84e+02
.ENDS GRM21A5C2E330FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E330GW01
* Property : C = 3.30e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E330GW01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.35e-11
R03 N02 N03 1.71e-01
C04 N03 N04 3.13e-10
L04 N03 N04 1.32e-11
R04 N03 N04 1.92e+00
C05 N04 N05 3.31e-11
L05 N04 N05 5.59e-11
R05 N04 N05 8.23e+00
C06 N05 Port2 8.74e-13
L06 N05 Port2 4.49e-10
R06 N05 Port2 1.84e+02
.ENDS GRM21A5C2E330GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E330JW01
* Property : C = 3.30e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E330JW01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.35e-11
R03 N02 N03 1.71e-01
C04 N03 N04 3.13e-10
L04 N03 N04 1.32e-11
R04 N03 N04 1.92e+00
C05 N04 N05 3.31e-11
L05 N04 N05 5.59e-11
R05 N04 N05 8.23e+00
C06 N05 Port2 8.74e-13
L06 N05 Port2 4.49e-10
R06 N05 Port2 1.84e+02
.ENDS GRM21A5C2E330JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E331FW01
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E331FW01 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 6.35e-02
C04 N03 N04 1.20e-09
L04 N03 N04 2.60e-11
R04 N03 N04 1.54e+00
C05 N04 N05 3.37e-10
L05 N04 N05 3.77e-11
R05 N04 N05 2.10e+00
C06 N05 N06 1.28e-09
L06 N05 N06 4.72e-12
R06 N05 N06 4.00e-01
C07 N06 N07 2.43e-10
L07 N06 N07 1.45e-11
R07 N06 N07 1.03e+00
C08 N07 Port2 1.35e-12
L08 N07 Port2 2.14e-10
R08 N07 Port2 5.46e+01
.ENDS GRM21A5C2E331FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E331GW01
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E331GW01 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 6.35e-02
C04 N03 N04 1.20e-09
L04 N03 N04 2.60e-11
R04 N03 N04 1.54e+00
C05 N04 N05 3.37e-10
L05 N04 N05 3.77e-11
R05 N04 N05 2.10e+00
C06 N05 N06 1.28e-09
L06 N05 N06 4.72e-12
R06 N05 N06 4.00e-01
C07 N06 N07 2.43e-10
L07 N06 N07 1.45e-11
R07 N06 N07 1.03e+00
C08 N07 Port2 1.35e-12
L08 N07 Port2 2.14e-10
R08 N07 Port2 5.46e+01
.ENDS GRM21A5C2E331GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E331JW01
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E331JW01 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 6.35e-02
C04 N03 N04 1.20e-09
L04 N03 N04 2.60e-11
R04 N03 N04 1.54e+00
C05 N04 N05 3.37e-10
L05 N04 N05 3.77e-11
R05 N04 N05 2.10e+00
C06 N05 N06 1.28e-09
L06 N05 N06 4.72e-12
R06 N05 N06 4.00e-01
C07 N06 N07 2.43e-10
L07 N06 N07 1.45e-11
R07 N06 N07 1.03e+00
C08 N07 Port2 1.35e-12
L08 N07 Port2 2.14e-10
R08 N07 Port2 5.46e+01
.ENDS GRM21A5C2E331JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E390FW01
* Property : C = 3.90e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E390FW01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.47e-11
R03 N02 N03 1.73e-01
C04 N03 N04 5.69e-10
L04 N03 N04 6.61e-12
R04 N03 N04 8.00e-01
C05 N04 N05 3.24e-11
L05 N04 N05 4.34e-11
R05 N04 N05 7.33e+00
C06 N05 Port2 6.95e-13
L06 N05 Port2 5.66e-10
R06 N05 Port2 2.32e+02
.ENDS GRM21A5C2E390FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E390GW01
* Property : C = 3.90e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E390GW01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.47e-11
R03 N02 N03 1.73e-01
C04 N03 N04 5.69e-10
L04 N03 N04 6.61e-12
R04 N03 N04 8.00e-01
C05 N04 N05 3.24e-11
L05 N04 N05 4.34e-11
R05 N04 N05 7.33e+00
C06 N05 Port2 6.95e-13
L06 N05 Port2 5.66e-10
R06 N05 Port2 2.32e+02
.ENDS GRM21A5C2E390GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E390JW01
* Property : C = 3.90e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E390JW01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.47e-11
R03 N02 N03 1.73e-01
C04 N03 N04 5.69e-10
L04 N03 N04 6.61e-12
R04 N03 N04 8.00e-01
C05 N04 N05 3.24e-11
L05 N04 N05 4.34e-11
R05 N04 N05 7.33e+00
C06 N05 Port2 6.95e-13
L06 N05 Port2 5.66e-10
R06 N05 Port2 2.32e+02
.ENDS GRM21A5C2E390JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E391FWA1
* Property : C = 3.90e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E391FWA1 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.18e-10
R03 N02 N03 4.49e-03
C04 N03 N04 1.29e-08
R04 N03 N04 9.16e+01
L05 N04 N05 6.38e-11
R05 N04 N05 7.53e-02
C06 N05 N06 7.99e-08
L06 N05 N06 5.21e-11
R06 N05 N06 2.02e-02
C07 N06 N07 2.84e-09
L07 N06 N07 1.12e-11
R07 N06 N07 3.78e-01
C08 N07 N08 3.40e-10
L08 N07 N08 3.30e-11
R08 N07 N08 1.08e+00
C09 N08 N09 2.07e-10
L09 N08 N09 1.29e-11
R09 N08 N09 3.81e-01
C10 N09 Port2 8.69e-13
L10 N09 Port2 4.04e-10
R10 N09 Port2 1.24e+02
.ENDS GRM21A5C2E391FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E391GWA1
* Property : C = 3.90e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E391GWA1 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.18e-10
R03 N02 N03 4.49e-03
C04 N03 N04 1.29e-08
R04 N03 N04 9.16e+01
L05 N04 N05 6.38e-11
R05 N04 N05 7.53e-02
C06 N05 N06 7.99e-08
L06 N05 N06 5.21e-11
R06 N05 N06 2.02e-02
C07 N06 N07 2.84e-09
L07 N06 N07 1.12e-11
R07 N06 N07 3.78e-01
C08 N07 N08 3.40e-10
L08 N07 N08 3.30e-11
R08 N07 N08 1.08e+00
C09 N08 N09 2.07e-10
L09 N08 N09 1.29e-11
R09 N08 N09 3.81e-01
C10 N09 Port2 8.69e-13
L10 N09 Port2 4.04e-10
R10 N09 Port2 1.24e+02
.ENDS GRM21A5C2E391GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E391JWA1
* Property : C = 3.90e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E391JWA1 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.18e-10
R03 N02 N03 4.49e-03
C04 N03 N04 1.29e-08
R04 N03 N04 9.16e+01
L05 N04 N05 6.38e-11
R05 N04 N05 7.53e-02
C06 N05 N06 7.99e-08
L06 N05 N06 5.21e-11
R06 N05 N06 2.02e-02
C07 N06 N07 2.84e-09
L07 N06 N07 1.12e-11
R07 N06 N07 3.78e-01
C08 N07 N08 3.40e-10
L08 N07 N08 3.30e-11
R08 N07 N08 1.08e+00
C09 N08 N09 2.07e-10
L09 N08 N09 1.29e-11
R09 N08 N09 3.81e-01
C10 N09 Port2 8.69e-13
L10 N09 Port2 4.04e-10
R10 N09 Port2 1.24e+02
.ENDS GRM21A5C2E391JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E470FW01
* Property : C = 4.70e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E470FW01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.86e-10
R03 N02 N03 1.85e-01
C04 N03 N04 7.00e-10
L04 N03 N04 7.09e-12
R04 N03 N04 7.47e-01
C05 N04 N05 4.68e-11
L05 N04 N05 4.14e-11
R05 N04 N05 4.03e+00
C06 N05 Port2 1.29e-12
L06 N05 Port2 2.65e-10
R06 N05 Port2 5.83e+01
.ENDS GRM21A5C2E470FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E470GW01
* Property : C = 4.70e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E470GW01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.86e-10
R03 N02 N03 1.85e-01
C04 N03 N04 7.00e-10
L04 N03 N04 7.09e-12
R04 N03 N04 7.47e-01
C05 N04 N05 4.68e-11
L05 N04 N05 4.14e-11
R05 N04 N05 4.03e+00
C06 N05 Port2 1.29e-12
L06 N05 Port2 2.65e-10
R06 N05 Port2 5.83e+01
.ENDS GRM21A5C2E470GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E470JW01
* Property : C = 4.70e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E470JW01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.86e-10
R03 N02 N03 1.85e-01
C04 N03 N04 7.00e-10
L04 N03 N04 7.09e-12
R04 N03 N04 7.47e-01
C05 N04 N05 4.68e-11
L05 N04 N05 4.14e-11
R05 N04 N05 4.03e+00
C06 N05 Port2 1.29e-12
L06 N05 Port2 2.65e-10
R06 N05 Port2 5.83e+01
.ENDS GRM21A5C2E470JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E471FWA1
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E471FWA1 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.45e-11
R03 N02 N03 3.99e-03
C04 N03 N04 1.49e-07
R04 N03 N04 9.51e-01
L05 N04 N05 5.61e-11
R05 N04 N05 6.72e-02
C06 N05 N06 8.10e-08
L06 N05 N06 5.19e-11
R06 N05 N06 1.88e-02
C07 N06 N07 3.01e-09
L07 N06 N07 1.45e-11
R07 N06 N07 4.35e-01
C08 N07 N08 4.89e-10
L08 N07 N08 3.37e-11
R08 N07 N08 1.14e+00
C09 N08 N09 2.39e-10
L09 N08 N09 1.93e-11
R09 N08 N09 5.22e-01
C10 N09 N10 2.95e-10
L10 N09 N10 5.19e-12
R10 N09 N10 2.53e-01
C11 N10 Port2 7.58e-13
L11 N10 Port2 3.85e-10
R11 N10 Port2 2.98e+02
.ENDS GRM21A5C2E471FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E471GWA1
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E471GWA1 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.45e-11
R03 N02 N03 3.99e-03
C04 N03 N04 1.49e-07
R04 N03 N04 9.51e-01
L05 N04 N05 5.61e-11
R05 N04 N05 6.72e-02
C06 N05 N06 8.10e-08
L06 N05 N06 5.19e-11
R06 N05 N06 1.88e-02
C07 N06 N07 3.01e-09
L07 N06 N07 1.45e-11
R07 N06 N07 4.35e-01
C08 N07 N08 4.89e-10
L08 N07 N08 3.37e-11
R08 N07 N08 1.14e+00
C09 N08 N09 2.39e-10
L09 N08 N09 1.93e-11
R09 N08 N09 5.22e-01
C10 N09 N10 2.95e-10
L10 N09 N10 5.19e-12
R10 N09 N10 2.53e-01
C11 N10 Port2 7.58e-13
L11 N10 Port2 3.85e-10
R11 N10 Port2 2.98e+02
.ENDS GRM21A5C2E471GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E471JWA1
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E471JWA1 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.45e-11
R03 N02 N03 3.99e-03
C04 N03 N04 1.49e-07
R04 N03 N04 9.51e-01
L05 N04 N05 5.61e-11
R05 N04 N05 6.72e-02
C06 N05 N06 8.10e-08
L06 N05 N06 5.19e-11
R06 N05 N06 1.88e-02
C07 N06 N07 3.01e-09
L07 N06 N07 1.45e-11
R07 N06 N07 4.35e-01
C08 N07 N08 4.89e-10
L08 N07 N08 3.37e-11
R08 N07 N08 1.14e+00
C09 N08 N09 2.39e-10
L09 N08 N09 1.93e-11
R09 N08 N09 5.22e-01
C10 N09 N10 2.95e-10
L10 N09 N10 5.19e-12
R10 N09 N10 2.53e-01
C11 N10 Port2 7.58e-13
L11 N10 Port2 3.85e-10
R11 N10 Port2 2.98e+02
.ENDS GRM21A5C2E471JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E560FW01
* Property : C = 5.60e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E560FW01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 1.83e-01
C04 N03 N04 1.40e-09
L04 N03 N04 3.47e-12
R04 N03 N04 3.74e-01
C05 N04 N05 3.89e-11
L05 N04 N05 4.14e-11
R05 N04 N05 4.52e+00
C06 N05 Port2 7.11e-13
L06 N05 Port2 5.93e-10
R06 N05 Port2 2.32e+02
.ENDS GRM21A5C2E560FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E560GW01
* Property : C = 5.60e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E560GW01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 1.83e-01
C04 N03 N04 1.40e-09
L04 N03 N04 3.47e-12
R04 N03 N04 3.74e-01
C05 N04 N05 3.89e-11
L05 N04 N05 4.14e-11
R05 N04 N05 4.52e+00
C06 N05 Port2 7.11e-13
L06 N05 Port2 5.93e-10
R06 N05 Port2 2.32e+02
.ENDS GRM21A5C2E560GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E560JW01
* Property : C = 5.60e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E560JW01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 1.83e-01
C04 N03 N04 1.40e-09
L04 N03 N04 3.47e-12
R04 N03 N04 3.74e-01
C05 N04 N05 3.89e-11
L05 N04 N05 4.14e-11
R05 N04 N05 4.52e+00
C06 N05 Port2 7.11e-13
L06 N05 Port2 5.93e-10
R06 N05 Port2 2.32e+02
.ENDS GRM21A5C2E560JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E561FWA1
* Property : C = 5.60e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E561FWA1 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.53e-15
R03 N02 N03 6.87e-03
C04 N03 N04 1.36e-06
R04 N03 N04 1.09e-02
L05 N04 N05 3.69e-11
R05 N04 N05 8.22e-01
C06 N05 N06 8.26e-09
L06 N05 N06 7.29e-11
R06 N05 N06 3.48e-02
C07 N06 N07 2.87e-09
L07 N06 N07 2.03e-11
R07 N06 N07 5.33e-01
C08 N07 N08 6.09e-10
L08 N07 N08 3.83e-11
R08 N07 N08 1.05e+00
C09 N08 N09 2.90e-10
L09 N08 N09 2.13e-11
R09 N08 N09 4.35e-01
C10 N09 Port2 6.68e-13
L10 N09 Port2 4.38e-10
R10 N09 Port2 3.88e+02
.ENDS GRM21A5C2E561FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E561GWA1
* Property : C = 5.60e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E561GWA1 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.53e-15
R03 N02 N03 6.87e-03
C04 N03 N04 1.36e-06
R04 N03 N04 1.09e-02
L05 N04 N05 3.69e-11
R05 N04 N05 8.22e-01
C06 N05 N06 8.26e-09
L06 N05 N06 7.29e-11
R06 N05 N06 3.48e-02
C07 N06 N07 2.87e-09
L07 N06 N07 2.03e-11
R07 N06 N07 5.33e-01
C08 N07 N08 6.09e-10
L08 N07 N08 3.83e-11
R08 N07 N08 1.05e+00
C09 N08 N09 2.90e-10
L09 N08 N09 2.13e-11
R09 N08 N09 4.35e-01
C10 N09 Port2 6.68e-13
L10 N09 Port2 4.38e-10
R10 N09 Port2 3.88e+02
.ENDS GRM21A5C2E561GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E561JWA1
* Property : C = 5.60e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E561JWA1 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.53e-15
R03 N02 N03 6.87e-03
C04 N03 N04 1.36e-06
R04 N03 N04 1.09e-02
L05 N04 N05 3.69e-11
R05 N04 N05 8.22e-01
C06 N05 N06 8.26e-09
L06 N05 N06 7.29e-11
R06 N05 N06 3.48e-02
C07 N06 N07 2.87e-09
L07 N06 N07 2.03e-11
R07 N06 N07 5.33e-01
C08 N07 N08 6.09e-10
L08 N07 N08 3.83e-11
R08 N07 N08 1.05e+00
C09 N08 N09 2.90e-10
L09 N08 N09 2.13e-11
R09 N08 N09 4.35e-01
C10 N09 Port2 6.68e-13
L10 N09 Port2 4.38e-10
R10 N09 Port2 3.88e+02
.ENDS GRM21A5C2E561JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E680FW01
* Property : C = 6.80e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E680FW01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.55e-11
R03 N02 N03 1.91e-01
C04 N03 N04 2.02e-09
L04 N03 N04 3.17e-12
R04 N03 N04 2.97e-01
C05 N04 N05 7.77e-11
L05 N04 N05 3.14e-11
R05 N04 N05 2.79e+00
C06 N05 Port2 7.27e-13
L06 N05 Port2 6.06e-10
R06 N05 Port2 2.22e+02
.ENDS GRM21A5C2E680FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E680GW01
* Property : C = 6.80e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E680GW01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.55e-11
R03 N02 N03 1.91e-01
C04 N03 N04 2.02e-09
L04 N03 N04 3.17e-12
R04 N03 N04 2.97e-01
C05 N04 N05 7.77e-11
L05 N04 N05 3.14e-11
R05 N04 N05 2.79e+00
C06 N05 Port2 7.27e-13
L06 N05 Port2 6.06e-10
R06 N05 Port2 2.22e+02
.ENDS GRM21A5C2E680GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E680JW01
* Property : C = 6.80e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E680JW01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.55e-11
R03 N02 N03 1.91e-01
C04 N03 N04 2.02e-09
L04 N03 N04 3.17e-12
R04 N03 N04 2.97e-01
C05 N04 N05 7.77e-11
L05 N04 N05 3.14e-11
R05 N04 N05 2.79e+00
C06 N05 Port2 7.27e-13
L06 N05 Port2 6.06e-10
R06 N05 Port2 2.22e+02
.ENDS GRM21A5C2E680JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E681FWA1
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E681FWA1 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 1.10e-02
C04 N03 N04 4.92e-07
R04 N03 N04 3.02e-02
L05 N04 N05 1.73e-10
R05 N04 N05 5.14e-02
C06 N05 N06 5.54e-09
L06 N05 N06 9.29e-12
R06 N05 N06 1.84e-01
C07 N06 N07 5.32e-10
L07 N06 N07 3.16e-11
R07 N06 N07 6.62e-01
C08 N07 N08 3.51e-10
L08 N07 N08 1.28e-11
R08 N07 N08 3.16e-01
C09 N08 N09 5.52e-12
L09 N08 N09 6.80e-11
R09 N08 N09 4.07e+00
C10 N09 Port2 1.36e-12
L10 N09 Port2 2.16e-10
R10 N09 Port2 1.84e+02
.ENDS GRM21A5C2E681FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E681GWA1
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E681GWA1 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 1.10e-02
C04 N03 N04 4.92e-07
R04 N03 N04 3.02e-02
L05 N04 N05 1.73e-10
R05 N04 N05 5.14e-02
C06 N05 N06 5.54e-09
L06 N05 N06 9.29e-12
R06 N05 N06 1.84e-01
C07 N06 N07 5.32e-10
L07 N06 N07 3.16e-11
R07 N06 N07 6.62e-01
C08 N07 N08 3.51e-10
L08 N07 N08 1.28e-11
R08 N07 N08 3.16e-01
C09 N08 N09 5.52e-12
L09 N08 N09 6.80e-11
R09 N08 N09 4.07e+00
C10 N09 Port2 1.36e-12
L10 N09 Port2 2.16e-10
R10 N09 Port2 1.84e+02
.ENDS GRM21A5C2E681GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E681JWA1
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E681JWA1 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 1.10e-02
C04 N03 N04 4.92e-07
R04 N03 N04 3.02e-02
L05 N04 N05 1.73e-10
R05 N04 N05 5.14e-02
C06 N05 N06 5.54e-09
L06 N05 N06 9.29e-12
R06 N05 N06 1.84e-01
C07 N06 N07 5.32e-10
L07 N06 N07 3.16e-11
R07 N06 N07 6.62e-01
C08 N07 N08 3.51e-10
L08 N07 N08 1.28e-11
R08 N07 N08 3.16e-01
C09 N08 N09 5.52e-12
L09 N08 N09 6.80e-11
R09 N08 N09 4.07e+00
C10 N09 Port2 1.36e-12
L10 N09 Port2 2.16e-10
R10 N09 Port2 1.84e+02
.ENDS GRM21A5C2E681JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E820FW01
* Property : C = 8.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E820FW01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-10
R03 N02 N03 1.63e-01
C04 N03 N04 1.19e-09
L04 N03 N04 7.42e-12
R04 N03 N04 6.21e-01
C05 N04 N05 7.59e-11
L05 N04 N05 4.44e-11
R05 N04 N05 3.35e+00
C06 N05 Port2 1.15e-12
L06 N05 Port2 3.83e-10
R06 N05 Port2 1.40e+02
.ENDS GRM21A5C2E820FW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E820GW01
* Property : C = 8.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E820GW01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-10
R03 N02 N03 1.63e-01
C04 N03 N04 1.19e-09
L04 N03 N04 7.42e-12
R04 N03 N04 6.21e-01
C05 N04 N05 7.59e-11
L05 N04 N05 4.44e-11
R05 N04 N05 3.35e+00
C06 N05 Port2 1.15e-12
L06 N05 Port2 3.83e-10
R06 N05 Port2 1.40e+02
.ENDS GRM21A5C2E820GW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GRM21A5C2E820JW01
* Property : C = 8.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E820JW01 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-10
R03 N02 N03 1.63e-01
C04 N03 N04 1.19e-09
L04 N03 N04 7.42e-12
R04 N03 N04 6.21e-01
C05 N04 N05 7.59e-11
L05 N04 N05 4.44e-11
R05 N04 N05 3.35e+00
C06 N05 Port2 1.15e-12
L06 N05 Port2 3.83e-10
R06 N05 Port2 1.40e+02
.ENDS GRM21A5C2E820JW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E821FWA1
* Property : C = 8.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E821FWA1 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.20e-11
R03 N02 N03 2.88e-02
C04 N03 N04 4.81e-07
R04 N03 N04 3.08e-02
L05 N04 N05 5.98e-11
R05 N04 N05 6.30e-01
L06 N05 N06 7.14e-11
R06 N05 N06 2.36e-02
C07 N06 N07 1.13e-08
L07 N06 N07 6.07e-12
R07 N06 N07 1.85e-01
C08 N07 N08 1.04e-09
L08 N07 N08 2.38e-11
R08 N07 N08 5.01e-01
C09 N08 Port2 8.38e-13
L09 N08 Port2 4.01e-10
R09 N08 Port2 2.13e+02
.ENDS GRM21A5C2E821FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E821GWA1
* Property : C = 8.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E821GWA1 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.20e-11
R03 N02 N03 2.88e-02
C04 N03 N04 4.81e-07
R04 N03 N04 3.08e-02
L05 N04 N05 5.98e-11
R05 N04 N05 6.30e-01
L06 N05 N06 7.14e-11
R06 N05 N06 2.36e-02
C07 N06 N07 1.13e-08
L07 N06 N07 6.07e-12
R07 N06 N07 1.85e-01
C08 N07 N08 1.04e-09
L08 N07 N08 2.38e-11
R08 N07 N08 5.01e-01
C09 N08 Port2 8.38e-13
L09 N08 Port2 4.01e-10
R09 N08 Port2 2.13e+02
.ENDS GRM21A5C2E821GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-04[uF]/250[V]
* Murata P/N :GRM21A5C2E821JWA1
* Property : C = 8.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2E821JWA1 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.20e-11
R03 N02 N03 2.88e-02
C04 N03 N04 4.81e-07
R04 N03 N04 3.08e-02
L05 N04 N05 5.98e-11
R05 N04 N05 6.30e-01
L06 N05 N06 7.14e-11
R06 N05 N06 2.36e-02
C07 N06 N07 1.13e-08
L07 N06 N07 6.07e-12
R07 N06 N07 1.85e-01
C08 N07 N08 1.04e-09
L08 N07 N08 2.38e-11
R08 N07 N08 5.01e-01
C09 N08 Port2 8.38e-13
L09 N08 Port2 4.01e-10
R09 N08 Port2 2.13e+02
.ENDS GRM21A5C2E821JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J100FWA1
* Property : C = 1.00e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J100FWA1 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.46e-11
R03 N02 N03 2.34e-01
C04 N03 N04 6.66e-11
R04 N03 N04 2.81e+03
L05 N04 N05 3.12e-11
R05 N04 N05 3.04e-01
C06 N05 Port2 6.88e-13
L06 N05 Port2 5.25e-10
R06 N05 Port2 2.65e+02
.ENDS GRM21A5C2J100FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J100GWA1
* Property : C = 1.00e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J100GWA1 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.46e-11
R03 N02 N03 2.34e-01
C04 N03 N04 6.66e-11
R04 N03 N04 2.81e+03
L05 N04 N05 3.12e-11
R05 N04 N05 3.04e-01
C06 N05 Port2 6.88e-13
L06 N05 Port2 5.25e-10
R06 N05 Port2 2.65e+02
.ENDS GRM21A5C2J100GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J100JWA1
* Property : C = 1.00e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J100JWA1 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.46e-11
R03 N02 N03 2.34e-01
C04 N03 N04 6.66e-11
R04 N03 N04 2.81e+03
L05 N04 N05 3.12e-11
R05 N04 N05 3.04e-01
C06 N05 Port2 6.88e-13
L06 N05 Port2 5.25e-10
R06 N05 Port2 2.65e+02
.ENDS GRM21A5C2J100JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J101FWA1
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J101FWA1 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 1.18e-01
C04 N03 N04 7.87e-08
R04 N03 N04 1.50e-01
C05 N04 N05 6.46e-10
L05 N04 N05 1.38e-11
R05 N04 N05 9.47e-01
C06 N05 N06 8.49e-11
L06 N05 N06 3.94e-11
R06 N05 N06 2.69e+00
C07 N06 N07 4.51e-11
L07 N06 N07 2.05e-11
R07 N06 N07 1.88e+00
C08 N07 Port2 1.19e-12
L08 N07 Port2 2.76e-10
R08 N07 Port2 1.43e+02
.ENDS GRM21A5C2J101FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J101GWA1
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J101GWA1 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 1.18e-01
C04 N03 N04 7.87e-08
R04 N03 N04 1.50e-01
C05 N04 N05 6.46e-10
L05 N04 N05 1.38e-11
R05 N04 N05 9.47e-01
C06 N05 N06 8.49e-11
L06 N05 N06 3.94e-11
R06 N05 N06 2.69e+00
C07 N06 N07 4.51e-11
L07 N06 N07 2.05e-11
R07 N06 N07 1.88e+00
C08 N07 Port2 1.19e-12
L08 N07 Port2 2.76e-10
R08 N07 Port2 1.43e+02
.ENDS GRM21A5C2J101GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J101JWA1
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J101JWA1 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 1.18e-01
C04 N03 N04 7.87e-08
R04 N03 N04 1.50e-01
C05 N04 N05 6.46e-10
L05 N04 N05 1.38e-11
R05 N04 N05 9.47e-01
C06 N05 N06 8.49e-11
L06 N05 N06 3.94e-11
R06 N05 N06 2.69e+00
C07 N06 N07 4.51e-11
L07 N06 N07 2.05e-11
R07 N06 N07 1.88e+00
C08 N07 Port2 1.19e-12
L08 N07 Port2 2.76e-10
R08 N07 Port2 1.43e+02
.ENDS GRM21A5C2J101JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J120FWA1
* Property : C = 1.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J120FWA1 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.86e-11
R03 N02 N03 2.95e-01
C04 N03 N04 5.22e-09
R04 N03 N04 1.49e+01
L05 N04 N05 1.60e-11
R05 N04 N05 7.26e-01
C06 N05 N06 1.14e-11
L06 N05 N06 5.04e-11
R06 N05 N06 1.49e+01
C07 N06 Port2 8.42e-13
L07 N06 Port2 4.54e-10
R07 N06 Port2 2.06e+02
.ENDS GRM21A5C2J120FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J120GWA1
* Property : C = 1.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J120GWA1 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.86e-11
R03 N02 N03 2.95e-01
C04 N03 N04 5.22e-09
R04 N03 N04 1.49e+01
L05 N04 N05 1.60e-11
R05 N04 N05 7.26e-01
C06 N05 N06 1.14e-11
L06 N05 N06 5.04e-11
R06 N05 N06 1.49e+01
C07 N06 Port2 8.42e-13
L07 N06 Port2 4.54e-10
R07 N06 Port2 2.06e+02
.ENDS GRM21A5C2J120GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J120JWA1
* Property : C = 1.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J120JWA1 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.86e-11
R03 N02 N03 2.95e-01
C04 N03 N04 5.22e-09
R04 N03 N04 1.49e+01
L05 N04 N05 1.60e-11
R05 N04 N05 7.26e-01
C06 N05 N06 1.14e-11
L06 N05 N06 5.04e-11
R06 N05 N06 1.49e+01
C07 N06 Port2 8.42e-13
L07 N06 Port2 4.54e-10
R07 N06 Port2 2.06e+02
.ENDS GRM21A5C2J120JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J121FWA1
* Property : C = 1.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J121FWA1 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.95e-14
R03 N02 N03 1.22e-01
C04 N03 N04 2.50e-04
R04 N03 N04 1.49e-01
C05 N04 N05 6.61e-10
L05 N04 N05 1.00e-11
R05 N04 N05 4.51e-01
C06 N05 N06 8.33e-11
L06 N05 N06 2.37e-11
R06 N05 N06 2.00e+00
C07 N06 Port2 6.34e-13
L07 N06 Port2 5.70e-10
R07 N06 Port2 2.66e+02
.ENDS GRM21A5C2J121FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J121GWA1
* Property : C = 1.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J121GWA1 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.95e-14
R03 N02 N03 1.22e-01
C04 N03 N04 2.50e-04
R04 N03 N04 1.49e-01
C05 N04 N05 6.61e-10
L05 N04 N05 1.00e-11
R05 N04 N05 4.51e-01
C06 N05 N06 8.33e-11
L06 N05 N06 2.37e-11
R06 N05 N06 2.00e+00
C07 N06 Port2 6.34e-13
L07 N06 Port2 5.70e-10
R07 N06 Port2 2.66e+02
.ENDS GRM21A5C2J121GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J121JWA1
* Property : C = 1.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J121JWA1 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.95e-14
R03 N02 N03 1.22e-01
C04 N03 N04 2.50e-04
R04 N03 N04 1.49e-01
C05 N04 N05 6.61e-10
L05 N04 N05 1.00e-11
R05 N04 N05 4.51e-01
C06 N05 N06 8.33e-11
L06 N05 N06 2.37e-11
R06 N05 N06 2.00e+00
C07 N06 Port2 6.34e-13
L07 N06 Port2 5.70e-10
R07 N06 Port2 2.66e+02
.ENDS GRM21A5C2J121JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J150FWA1
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J150FWA1 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 2.50e-01
C04 N03 N04 3.57e-10
R04 N03 N04 3.87e+01
C05 N04 N05 3.12e-11
L05 N04 N05 3.29e-11
R05 N04 N05 8.92e+00
C06 N05 N06 8.86e-12
L06 N05 N06 8.77e-11
R06 N05 N06 1.51e+01
C07 N06 N07 2.89e-12
L07 N06 N07 2.14e-10
R07 N06 N07 7.44e+01
C08 N07 Port2 4.24e-12
L08 N07 Port2 9.57e-11
R08 N07 Port2 3.75e+01
.ENDS GRM21A5C2J150FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J150GWA1
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J150GWA1 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 2.50e-01
C04 N03 N04 3.57e-10
R04 N03 N04 3.87e+01
C05 N04 N05 3.12e-11
L05 N04 N05 3.29e-11
R05 N04 N05 8.92e+00
C06 N05 N06 8.86e-12
L06 N05 N06 8.77e-11
R06 N05 N06 1.51e+01
C07 N06 N07 2.89e-12
L07 N06 N07 2.14e-10
R07 N06 N07 7.44e+01
C08 N07 Port2 4.24e-12
L08 N07 Port2 9.57e-11
R08 N07 Port2 3.75e+01
.ENDS GRM21A5C2J150GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J150JWA1
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J150JWA1 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 2.50e-01
C04 N03 N04 3.57e-10
R04 N03 N04 3.87e+01
C05 N04 N05 3.12e-11
L05 N04 N05 3.29e-11
R05 N04 N05 8.92e+00
C06 N05 N06 8.86e-12
L06 N05 N06 8.77e-11
R06 N05 N06 1.51e+01
C07 N06 N07 2.89e-12
L07 N06 N07 2.14e-10
R07 N06 N07 7.44e+01
C08 N07 Port2 4.24e-12
L08 N07 Port2 9.57e-11
R08 N07 Port2 3.75e+01
.ENDS GRM21A5C2J150JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J151FWA1
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J151FWA1 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.08e-10
R03 N02 N03 1.04e-01
C04 N03 N04 9.33e-09
R04 N03 N04 3.32e+01
C05 N04 N05 9.70e-10
L05 N04 N05 1.04e-11
R05 N04 N05 4.57e-01
C06 N05 N06 8.99e-11
L06 N05 N06 3.53e-11
R06 N05 N06 1.95e+00
C07 N06 N07 3.72e-11
L07 N06 N07 1.90e-11
R07 N06 N07 1.58e+00
C08 N07 Port2 1.07e-12
L08 N07 Port2 3.22e-10
R08 N07 Port2 1.62e+02
.ENDS GRM21A5C2J151FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J151GWA1
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J151GWA1 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.08e-10
R03 N02 N03 1.04e-01
C04 N03 N04 9.33e-09
R04 N03 N04 3.32e+01
C05 N04 N05 9.70e-10
L05 N04 N05 1.04e-11
R05 N04 N05 4.57e-01
C06 N05 N06 8.99e-11
L06 N05 N06 3.53e-11
R06 N05 N06 1.95e+00
C07 N06 N07 3.72e-11
L07 N06 N07 1.90e-11
R07 N06 N07 1.58e+00
C08 N07 Port2 1.07e-12
L08 N07 Port2 3.22e-10
R08 N07 Port2 1.62e+02
.ENDS GRM21A5C2J151GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J151JWA1
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J151JWA1 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.08e-10
R03 N02 N03 1.04e-01
C04 N03 N04 9.33e-09
R04 N03 N04 3.32e+01
C05 N04 N05 9.70e-10
L05 N04 N05 1.04e-11
R05 N04 N05 4.57e-01
C06 N05 N06 8.99e-11
L06 N05 N06 3.53e-11
R06 N05 N06 1.95e+00
C07 N06 N07 3.72e-11
L07 N06 N07 1.90e-11
R07 N06 N07 1.58e+00
C08 N07 Port2 1.07e-12
L08 N07 Port2 3.22e-10
R08 N07 Port2 1.62e+02
.ENDS GRM21A5C2J151JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J180FWA1
* Property : C = 1.80e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J180FWA1 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.02e-10
R03 N02 N03 2.42e-01
C04 N03 N04 2.78e-06
R04 N03 N04 1.07e+02
C05 N04 N05 2.08e-10
L05 N04 N05 5.62e-12
R05 N04 N05 2.42e+00
C06 N05 N06 4.09e-12
L06 N05 N06 1.28e-10
R06 N05 N06 5.58e+01
C07 N06 Port2 9.28e-13
L07 N06 Port2 3.31e-10
R07 N06 Port2 9.61e+01
.ENDS GRM21A5C2J180FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J180GWA1
* Property : C = 1.80e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J180GWA1 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.02e-10
R03 N02 N03 2.42e-01
C04 N03 N04 2.78e-06
R04 N03 N04 1.07e+02
C05 N04 N05 2.08e-10
L05 N04 N05 5.62e-12
R05 N04 N05 2.42e+00
C06 N05 N06 4.09e-12
L06 N05 N06 1.28e-10
R06 N05 N06 5.58e+01
C07 N06 Port2 9.28e-13
L07 N06 Port2 3.31e-10
R07 N06 Port2 9.61e+01
.ENDS GRM21A5C2J180GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J180JWA1
* Property : C = 1.80e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J180JWA1 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.02e-10
R03 N02 N03 2.42e-01
C04 N03 N04 2.78e-06
R04 N03 N04 1.07e+02
C05 N04 N05 2.08e-10
L05 N04 N05 5.62e-12
R05 N04 N05 2.42e+00
C06 N05 N06 4.09e-12
L06 N05 N06 1.28e-10
R06 N05 N06 5.58e+01
C07 N06 Port2 9.28e-13
L07 N06 Port2 3.31e-10
R07 N06 Port2 9.61e+01
.ENDS GRM21A5C2J180JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J181FWA1
* Property : C = 1.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J181FWA1 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 9.35e-02
C04 N03 N04 2.18e-07
R04 N03 N04 6.80e-02
C05 N04 N05 1.28e-09
L05 N04 N05 1.07e-11
R05 N04 N05 4.83e-01
C06 N05 N06 1.37e-10
L06 N05 N06 3.39e-11
R06 N05 N06 1.71e+00
C07 N06 N07 8.86e-11
L07 N06 N07 1.31e-11
R07 N06 N07 8.59e-01
C08 N07 N08 2.46e-12
L08 N07 N08 1.38e-10
R08 N07 N08 3.73e+01
C09 N08 Port2 1.25e-12
L09 N08 Port2 2.25e-10
R09 N08 Port2 3.16e+02
.ENDS GRM21A5C2J181FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J181GWA1
* Property : C = 1.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J181GWA1 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 9.35e-02
C04 N03 N04 2.18e-07
R04 N03 N04 6.80e-02
C05 N04 N05 1.28e-09
L05 N04 N05 1.07e-11
R05 N04 N05 4.83e-01
C06 N05 N06 1.37e-10
L06 N05 N06 3.39e-11
R06 N05 N06 1.71e+00
C07 N06 N07 8.86e-11
L07 N06 N07 1.31e-11
R07 N06 N07 8.59e-01
C08 N07 N08 2.46e-12
L08 N07 N08 1.38e-10
R08 N07 N08 3.73e+01
C09 N08 Port2 1.25e-12
L09 N08 Port2 2.25e-10
R09 N08 Port2 3.16e+02
.ENDS GRM21A5C2J181GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J181JWA1
* Property : C = 1.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J181JWA1 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 9.35e-02
C04 N03 N04 2.18e-07
R04 N03 N04 6.80e-02
C05 N04 N05 1.28e-09
L05 N04 N05 1.07e-11
R05 N04 N05 4.83e-01
C06 N05 N06 1.37e-10
L06 N05 N06 3.39e-11
R06 N05 N06 1.71e+00
C07 N06 N07 8.86e-11
L07 N06 N07 1.31e-11
R07 N06 N07 8.59e-01
C08 N07 N08 2.46e-12
L08 N07 N08 1.38e-10
R08 N07 N08 3.73e+01
C09 N08 Port2 1.25e-12
L09 N08 Port2 2.25e-10
R09 N08 Port2 3.16e+02
.ENDS GRM21A5C2J181JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J220FWA1
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J220FWA1 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-15
R03 N02 N03 2.18e-01
C04 N03 N04 3.06e-09
R04 N03 N04 4.84e+00
C05 N04 N05 1.42e-10
L05 N04 N05 1.12e-11
R05 N04 N05 2.65e+00
C06 N05 N06 7.69e-12
L06 N05 N06 8.58e-11
R06 N05 N06 2.68e+01
C07 N06 N07 5.76e-12
L07 N06 N07 8.15e-11
R07 N06 N07 1.05e+01
C08 N07 Port2 8.10e-13
L08 N07 Port2 3.77e-10
R08 N07 Port2 4.71e+02
.ENDS GRM21A5C2J220FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J220GWA1
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J220GWA1 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-15
R03 N02 N03 2.18e-01
C04 N03 N04 3.06e-09
R04 N03 N04 4.84e+00
C05 N04 N05 1.42e-10
L05 N04 N05 1.12e-11
R05 N04 N05 2.65e+00
C06 N05 N06 7.69e-12
L06 N05 N06 8.58e-11
R06 N05 N06 2.68e+01
C07 N06 N07 5.76e-12
L07 N06 N07 8.15e-11
R07 N06 N07 1.05e+01
C08 N07 Port2 8.10e-13
L08 N07 Port2 3.77e-10
R08 N07 Port2 4.71e+02
.ENDS GRM21A5C2J220GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J220JWA1
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J220JWA1 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-15
R03 N02 N03 2.18e-01
C04 N03 N04 3.06e-09
R04 N03 N04 4.84e+00
C05 N04 N05 1.42e-10
L05 N04 N05 1.12e-11
R05 N04 N05 2.65e+00
C06 N05 N06 7.69e-12
L06 N05 N06 8.58e-11
R06 N05 N06 2.68e+01
C07 N06 N07 5.76e-12
L07 N06 N07 8.15e-11
R07 N06 N07 1.05e+01
C08 N07 Port2 8.10e-13
L08 N07 Port2 3.77e-10
R08 N07 Port2 4.71e+02
.ENDS GRM21A5C2J220JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J221FWA1
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J221FWA1 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 1.21e-02
C04 N03 N04 9.96e-09
R04 N03 N04 9.40e+03
L05 N04 N05 1.02e-10
R05 N04 N05 7.69e-02
C06 N05 N06 2.88e-07
L06 N05 N06 1.71e-11
R06 N05 N06 1.12e-02
C07 N06 N07 1.55e-09
L07 N06 N07 1.24e-11
R07 N06 N07 5.22e-01
C08 N07 N08 1.96e-10
L08 N07 N08 3.48e-11
R08 N07 N08 1.46e+00
C09 N08 N09 9.40e-11
L09 N08 N09 1.89e-11
R09 N08 N09 8.12e-01
C10 N09 Port2 8.88e-13
L10 N09 Port2 3.30e-10
R10 N09 Port2 1.44e+02
.ENDS GRM21A5C2J221FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J221GWA1
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J221GWA1 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 1.21e-02
C04 N03 N04 9.96e-09
R04 N03 N04 9.40e+03
L05 N04 N05 1.02e-10
R05 N04 N05 7.69e-02
C06 N05 N06 2.88e-07
L06 N05 N06 1.71e-11
R06 N05 N06 1.12e-02
C07 N06 N07 1.55e-09
L07 N06 N07 1.24e-11
R07 N06 N07 5.22e-01
C08 N07 N08 1.96e-10
L08 N07 N08 3.48e-11
R08 N07 N08 1.46e+00
C09 N08 N09 9.40e-11
L09 N08 N09 1.89e-11
R09 N08 N09 8.12e-01
C10 N09 Port2 8.88e-13
L10 N09 Port2 3.30e-10
R10 N09 Port2 1.44e+02
.ENDS GRM21A5C2J221GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J221JWA1
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J221JWA1 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 1.21e-02
C04 N03 N04 9.96e-09
R04 N03 N04 9.40e+03
L05 N04 N05 1.02e-10
R05 N04 N05 7.69e-02
C06 N05 N06 2.88e-07
L06 N05 N06 1.71e-11
R06 N05 N06 1.12e-02
C07 N06 N07 1.55e-09
L07 N06 N07 1.24e-11
R07 N06 N07 5.22e-01
C08 N07 N08 1.96e-10
L08 N07 N08 3.48e-11
R08 N07 N08 1.46e+00
C09 N08 N09 9.40e-11
L09 N08 N09 1.89e-11
R09 N08 N09 8.12e-01
C10 N09 Port2 8.88e-13
L10 N09 Port2 3.30e-10
R10 N09 Port2 1.44e+02
.ENDS GRM21A5C2J221JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J270FWA1
* Property : C = 2.70e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J270FWA1 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.21e-12
R03 N02 N03 2.01e-01
C04 N03 N04 5.67e-09
R04 N03 N04 2.62e+00
C05 N04 Port2 6.48e-13
L05 N04 Port2 6.34e-10
R05 N04 Port2 1.31e+02
.ENDS GRM21A5C2J270FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J270GWA1
* Property : C = 2.70e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J270GWA1 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.21e-12
R03 N02 N03 2.01e-01
C04 N03 N04 5.67e-09
R04 N03 N04 2.62e+00
C05 N04 Port2 6.48e-13
L05 N04 Port2 6.34e-10
R05 N04 Port2 1.31e+02
.ENDS GRM21A5C2J270GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J270JWA1
* Property : C = 2.70e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J270JWA1 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.21e-12
R03 N02 N03 2.01e-01
C04 N03 N04 5.67e-09
R04 N03 N04 2.62e+00
C05 N04 Port2 6.48e-13
L05 N04 Port2 6.34e-10
R05 N04 Port2 1.31e+02
.ENDS GRM21A5C2J270JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J271FWA1
* Property : C = 2.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J271FWA1 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.82e-11
R03 N02 N03 5.28e-03
C04 N03 N04 6.01e-09
R04 N03 N04 5.93e+02
L05 N04 N05 5.93e-11
R05 N04 N05 7.03e-02
C06 N05 N06 9.97e-08
L06 N05 N06 3.48e-11
R06 N05 N06 1.74e-02
C07 N06 N07 1.44e-09
L07 N06 N07 1.75e-11
R07 N06 N07 8.84e-01
C08 N07 N08 2.63e-10
L08 N07 N08 3.62e-11
R08 N07 N08 1.91e+00
C09 N08 N09 1.05e-10
L09 N08 N09 2.43e-11
R09 N08 N09 7.41e-01
C10 N09 Port2 8.41e-13
L10 N09 Port2 4.00e-10
R10 N09 Port2 2.14e+02
.ENDS GRM21A5C2J271FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J271GWA1
* Property : C = 2.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J271GWA1 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.82e-11
R03 N02 N03 5.28e-03
C04 N03 N04 6.01e-09
R04 N03 N04 5.93e+02
L05 N04 N05 5.93e-11
R05 N04 N05 7.03e-02
C06 N05 N06 9.97e-08
L06 N05 N06 3.48e-11
R06 N05 N06 1.74e-02
C07 N06 N07 1.44e-09
L07 N06 N07 1.75e-11
R07 N06 N07 8.84e-01
C08 N07 N08 2.63e-10
L08 N07 N08 3.62e-11
R08 N07 N08 1.91e+00
C09 N08 N09 1.05e-10
L09 N08 N09 2.43e-11
R09 N08 N09 7.41e-01
C10 N09 Port2 8.41e-13
L10 N09 Port2 4.00e-10
R10 N09 Port2 2.14e+02
.ENDS GRM21A5C2J271GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J271JWA1
* Property : C = 2.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J271JWA1 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.82e-11
R03 N02 N03 5.28e-03
C04 N03 N04 6.01e-09
R04 N03 N04 5.93e+02
L05 N04 N05 5.93e-11
R05 N04 N05 7.03e-02
C06 N05 N06 9.97e-08
L06 N05 N06 3.48e-11
R06 N05 N06 1.74e-02
C07 N06 N07 1.44e-09
L07 N06 N07 1.75e-11
R07 N06 N07 8.84e-01
C08 N07 N08 2.63e-10
L08 N07 N08 3.62e-11
R08 N07 N08 1.91e+00
C09 N08 N09 1.05e-10
L09 N08 N09 2.43e-11
R09 N08 N09 7.41e-01
C10 N09 Port2 8.41e-13
L10 N09 Port2 4.00e-10
R10 N09 Port2 2.14e+02
.ENDS GRM21A5C2J271JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J330FWA1
* Property : C = 3.30e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J330FWA1 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.68e-10
R03 N02 N03 2.14e-01
C04 N03 N04 1.93e-08
R04 N03 N04 4.14e+00
L05 N04 N05 2.88e-11
R05 N04 N05 1.42e+00
C06 N05 N06 2.16e-12
L06 N05 N06 1.99e-10
R06 N05 N06 4.81e+01
C07 N06 Port2 1.16e-12
L07 N06 Port2 2.87e-10
R07 N06 Port2 1.14e+02
.ENDS GRM21A5C2J330FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J330GWA1
* Property : C = 3.30e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J330GWA1 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.68e-10
R03 N02 N03 2.14e-01
C04 N03 N04 1.93e-08
R04 N03 N04 4.14e+00
L05 N04 N05 2.88e-11
R05 N04 N05 1.42e+00
C06 N05 N06 2.16e-12
L06 N05 N06 1.99e-10
R06 N05 N06 4.81e+01
C07 N06 Port2 1.16e-12
L07 N06 Port2 2.87e-10
R07 N06 Port2 1.14e+02
.ENDS GRM21A5C2J330GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J330JWA1
* Property : C = 3.30e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J330JWA1 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.68e-10
R03 N02 N03 2.14e-01
C04 N03 N04 1.93e-08
R04 N03 N04 4.14e+00
L05 N04 N05 2.88e-11
R05 N04 N05 1.42e+00
C06 N05 N06 2.16e-12
L06 N05 N06 1.99e-10
R06 N05 N06 4.81e+01
C07 N06 Port2 1.16e-12
L07 N06 Port2 2.87e-10
R07 N06 Port2 1.14e+02
.ENDS GRM21A5C2J330JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J331FWA1
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J331FWA1 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 5.23e-03
C04 N03 N04 3.70e-08
R04 N03 N04 1.03e+01
L05 N04 N05 6.69e-11
R05 N04 N05 6.66e-02
C06 N05 N06 1.31e-07
L06 N05 N06 3.86e-11
R06 N05 N06 1.76e-02
C07 N06 N07 2.91e-09
L07 N06 N07 8.92e-12
R07 N06 N07 3.04e-01
C08 N07 N08 3.19e-10
L08 N07 N08 2.76e-11
R08 N07 N08 9.16e-01
C09 N08 N09 2.63e-11
L09 N08 N09 3.75e-11
R09 N08 N09 7.66e-01
C10 N09 Port2 7.76e-13
L10 N09 Port2 3.78e-10
R10 N09 Port2 5.05e+02
.ENDS GRM21A5C2J331FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J331GWA1
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J331GWA1 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 5.23e-03
C04 N03 N04 3.70e-08
R04 N03 N04 1.03e+01
L05 N04 N05 6.69e-11
R05 N04 N05 6.66e-02
C06 N05 N06 1.31e-07
L06 N05 N06 3.86e-11
R06 N05 N06 1.76e-02
C07 N06 N07 2.91e-09
L07 N06 N07 8.92e-12
R07 N06 N07 3.04e-01
C08 N07 N08 3.19e-10
L08 N07 N08 2.76e-11
R08 N07 N08 9.16e-01
C09 N08 N09 2.63e-11
L09 N08 N09 3.75e-11
R09 N08 N09 7.66e-01
C10 N09 Port2 7.76e-13
L10 N09 Port2 3.78e-10
R10 N09 Port2 5.05e+02
.ENDS GRM21A5C2J331GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J331JWA1
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J331JWA1 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 5.23e-03
C04 N03 N04 3.70e-08
R04 N03 N04 1.03e+01
L05 N04 N05 6.69e-11
R05 N04 N05 6.66e-02
C06 N05 N06 1.31e-07
L06 N05 N06 3.86e-11
R06 N05 N06 1.76e-02
C07 N06 N07 2.91e-09
L07 N06 N07 8.92e-12
R07 N06 N07 3.04e-01
C08 N07 N08 3.19e-10
L08 N07 N08 2.76e-11
R08 N07 N08 9.16e-01
C09 N08 N09 2.63e-11
L09 N08 N09 3.75e-11
R09 N08 N09 7.66e-01
C10 N09 Port2 7.76e-13
L10 N09 Port2 3.78e-10
R10 N09 Port2 5.05e+02
.ENDS GRM21A5C2J331JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J390FWA1
* Property : C = 3.90e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J390FWA1 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 2.08e-01
C04 N03 N04 1.18e-08
R04 N03 N04 1.26e+00
L05 N04 N05 8.26e-12
R05 N04 N05 1.11e-01
C06 N05 N06 2.62e-11
L06 N05 N06 2.20e-11
R06 N05 N06 7.40e+00
C07 N06 Port2 7.74e-13
L07 N06 Port2 4.36e-10
R07 N06 Port2 1.58e+02
.ENDS GRM21A5C2J390FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J390GWA1
* Property : C = 3.90e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J390GWA1 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 2.08e-01
C04 N03 N04 1.18e-08
R04 N03 N04 1.26e+00
L05 N04 N05 8.26e-12
R05 N04 N05 1.11e-01
C06 N05 N06 2.62e-11
L06 N05 N06 2.20e-11
R06 N05 N06 7.40e+00
C07 N06 Port2 7.74e-13
L07 N06 Port2 4.36e-10
R07 N06 Port2 1.58e+02
.ENDS GRM21A5C2J390GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J390JWA1
* Property : C = 3.90e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J390JWA1 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 2.08e-01
C04 N03 N04 1.18e-08
R04 N03 N04 1.26e+00
L05 N04 N05 8.26e-12
R05 N04 N05 1.11e-01
C06 N05 N06 2.62e-11
L06 N05 N06 2.20e-11
R06 N05 N06 7.40e+00
C07 N06 Port2 7.74e-13
L07 N06 Port2 4.36e-10
R07 N06 Port2 1.58e+02
.ENDS GRM21A5C2J390JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J391FWA1
* Property : C = 3.90e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J391FWA1 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.18e-10
R03 N02 N03 4.49e-03
C04 N03 N04 1.29e-08
R04 N03 N04 9.16e+01
L05 N04 N05 6.38e-11
R05 N04 N05 7.53e-02
C06 N05 N06 7.99e-08
L06 N05 N06 5.21e-11
R06 N05 N06 2.02e-02
C07 N06 N07 2.84e-09
L07 N06 N07 1.12e-11
R07 N06 N07 3.78e-01
C08 N07 N08 3.40e-10
L08 N07 N08 3.30e-11
R08 N07 N08 1.08e+00
C09 N08 N09 2.07e-10
L09 N08 N09 1.29e-11
R09 N08 N09 3.81e-01
C10 N09 Port2 8.69e-13
L10 N09 Port2 4.04e-10
R10 N09 Port2 1.24e+02
.ENDS GRM21A5C2J391FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J391GWA1
* Property : C = 3.90e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J391GWA1 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.18e-10
R03 N02 N03 4.49e-03
C04 N03 N04 1.29e-08
R04 N03 N04 9.16e+01
L05 N04 N05 6.38e-11
R05 N04 N05 7.53e-02
C06 N05 N06 7.99e-08
L06 N05 N06 5.21e-11
R06 N05 N06 2.02e-02
C07 N06 N07 2.84e-09
L07 N06 N07 1.12e-11
R07 N06 N07 3.78e-01
C08 N07 N08 3.40e-10
L08 N07 N08 3.30e-11
R08 N07 N08 1.08e+00
C09 N08 N09 2.07e-10
L09 N08 N09 1.29e-11
R09 N08 N09 3.81e-01
C10 N09 Port2 8.69e-13
L10 N09 Port2 4.04e-10
R10 N09 Port2 1.24e+02
.ENDS GRM21A5C2J391GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J391JWA1
* Property : C = 3.90e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J391JWA1 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.18e-10
R03 N02 N03 4.49e-03
C04 N03 N04 1.29e-08
R04 N03 N04 9.16e+01
L05 N04 N05 6.38e-11
R05 N04 N05 7.53e-02
C06 N05 N06 7.99e-08
L06 N05 N06 5.21e-11
R06 N05 N06 2.02e-02
C07 N06 N07 2.84e-09
L07 N06 N07 1.12e-11
R07 N06 N07 3.78e-01
C08 N07 N08 3.40e-10
L08 N07 N08 3.30e-11
R08 N07 N08 1.08e+00
C09 N08 N09 2.07e-10
L09 N08 N09 1.29e-11
R09 N08 N09 3.81e-01
C10 N09 Port2 8.69e-13
L10 N09 Port2 4.04e-10
R10 N09 Port2 1.24e+02
.ENDS GRM21A5C2J391JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J470FWA1
* Property : C = 4.70e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J470FWA1 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-11
R03 N02 N03 1.85e-01
C04 N03 N04 2.36e-08
R04 N03 N04 6.29e-01
C05 N04 N05 6.02e-10
L05 N04 N05 4.17e-12
R05 N04 N05 4.88e-01
C06 N05 N06 2.16e-11
L06 N05 N06 4.03e-11
R06 N05 N06 8.23e+00
C07 N06 Port2 7.26e-13
L07 N06 Port2 5.42e-10
R07 N06 Port2 2.03e+02
.ENDS GRM21A5C2J470FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J470GWA1
* Property : C = 4.70e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J470GWA1 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-11
R03 N02 N03 1.85e-01
C04 N03 N04 2.36e-08
R04 N03 N04 6.29e-01
C05 N04 N05 6.02e-10
L05 N04 N05 4.17e-12
R05 N04 N05 4.88e-01
C06 N05 N06 2.16e-11
L06 N05 N06 4.03e-11
R06 N05 N06 8.23e+00
C07 N06 Port2 7.26e-13
L07 N06 Port2 5.42e-10
R07 N06 Port2 2.03e+02
.ENDS GRM21A5C2J470GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J470JWA1
* Property : C = 4.70e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J470JWA1 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-11
R03 N02 N03 1.85e-01
C04 N03 N04 2.36e-08
R04 N03 N04 6.29e-01
C05 N04 N05 6.02e-10
L05 N04 N05 4.17e-12
R05 N04 N05 4.88e-01
C06 N05 N06 2.16e-11
L06 N05 N06 4.03e-11
R06 N05 N06 8.23e+00
C07 N06 Port2 7.26e-13
L07 N06 Port2 5.42e-10
R07 N06 Port2 2.03e+02
.ENDS GRM21A5C2J470JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J471FWA1
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J471FWA1 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 4.27e-04
C04 N03 N04 2.92e-08
R04 N03 N04 2.12e+01
L05 N04 N05 5.32e-11
R05 N04 N05 1.11e+00
L06 N05 N06 1.22e-10
R06 N05 N06 5.18e-02
C07 N06 N07 3.31e-09
L07 N06 N07 1.38e-11
R07 N06 N07 4.89e-01
C08 N07 N08 5.15e-10
L08 N07 N08 3.29e-11
R08 N07 N08 1.15e+00
C09 N08 N09 4.74e-10
L09 N08 N09 9.52e-12
R09 N08 N09 3.38e-01
C10 N09 Port2 1.14e-12
L10 N09 Port2 2.76e-10
R10 N09 Port2 1.17e+02
.ENDS GRM21A5C2J471FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J471GWA1
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J471GWA1 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 4.27e-04
C04 N03 N04 2.92e-08
R04 N03 N04 2.12e+01
L05 N04 N05 5.32e-11
R05 N04 N05 1.11e+00
L06 N05 N06 1.22e-10
R06 N05 N06 5.18e-02
C07 N06 N07 3.31e-09
L07 N06 N07 1.38e-11
R07 N06 N07 4.89e-01
C08 N07 N08 5.15e-10
L08 N07 N08 3.29e-11
R08 N07 N08 1.15e+00
C09 N08 N09 4.74e-10
L09 N08 N09 9.52e-12
R09 N08 N09 3.38e-01
C10 N09 Port2 1.14e-12
L10 N09 Port2 2.76e-10
R10 N09 Port2 1.17e+02
.ENDS GRM21A5C2J471GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J471JWA1
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J471JWA1 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 4.27e-04
C04 N03 N04 2.92e-08
R04 N03 N04 2.12e+01
L05 N04 N05 5.32e-11
R05 N04 N05 1.11e+00
L06 N05 N06 1.22e-10
R06 N05 N06 5.18e-02
C07 N06 N07 3.31e-09
L07 N06 N07 1.38e-11
R07 N06 N07 4.89e-01
C08 N07 N08 5.15e-10
L08 N07 N08 3.29e-11
R08 N07 N08 1.15e+00
C09 N08 N09 4.74e-10
L09 N08 N09 9.52e-12
R09 N08 N09 3.38e-01
C10 N09 Port2 1.14e-12
L10 N09 Port2 2.76e-10
R10 N09 Port2 1.17e+02
.ENDS GRM21A5C2J471JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J560FWA1
* Property : C = 5.60e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J560FWA1 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.28e-15
R03 N02 N03 2.72e-02
C04 N03 N04 1.14e-08
R04 N03 N04 1.19e+00
L05 N04 N05 3.93e-11
R05 N04 N05 2.66e+00
L06 N05 N06 2.59e-10
R06 N05 N06 1.43e-01
C07 N06 N07 5.23e-10
L07 N06 N07 6.71e-12
R07 N06 N07 5.53e-01
C08 N07 N08 3.02e-11
L08 N07 N08 3.84e-11
R08 N07 N08 5.42e+00
C09 N08 Port2 8.47e-13
L09 N08 Port2 5.18e-10
R09 N08 Port2 3.96e+02
.ENDS GRM21A5C2J560FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J560GWA1
* Property : C = 5.60e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J560GWA1 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.28e-15
R03 N02 N03 2.72e-02
C04 N03 N04 1.14e-08
R04 N03 N04 1.19e+00
L05 N04 N05 3.93e-11
R05 N04 N05 2.66e+00
L06 N05 N06 2.59e-10
R06 N05 N06 1.43e-01
C07 N06 N07 5.23e-10
L07 N06 N07 6.71e-12
R07 N06 N07 5.53e-01
C08 N07 N08 3.02e-11
L08 N07 N08 3.84e-11
R08 N07 N08 5.42e+00
C09 N08 Port2 8.47e-13
L09 N08 Port2 5.18e-10
R09 N08 Port2 3.96e+02
.ENDS GRM21A5C2J560GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J560JWA1
* Property : C = 5.60e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J560JWA1 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.28e-15
R03 N02 N03 2.72e-02
C04 N03 N04 1.14e-08
R04 N03 N04 1.19e+00
L05 N04 N05 3.93e-11
R05 N04 N05 2.66e+00
L06 N05 N06 2.59e-10
R06 N05 N06 1.43e-01
C07 N06 N07 5.23e-10
L07 N06 N07 6.71e-12
R07 N06 N07 5.53e-01
C08 N07 N08 3.02e-11
L08 N07 N08 3.84e-11
R08 N07 N08 5.42e+00
C09 N08 Port2 8.47e-13
L09 N08 Port2 5.18e-10
R09 N08 Port2 3.96e+02
.ENDS GRM21A5C2J560JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J561FWA1
* Property : C = 5.60e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J561FWA1 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.77e-10
R03 N02 N03 1.27e-02
C04 N03 N04 8.90e-07
R04 N03 N04 1.67e-02
L05 N04 N05 8.56e-11
R05 N04 N05 3.49e-02
C06 N05 N06 3.64e-09
L06 N05 N06 1.55e-11
R06 N05 N06 4.88e-01
C07 N06 N07 5.93e-10
L07 N06 N07 3.78e-11
R07 N06 N07 1.07e+00
C08 N07 N08 3.24e-10
L08 N07 N08 1.84e-11
R08 N07 N08 4.52e-01
C09 N08 N09 3.66e-12
L09 N08 N09 8.04e-11
R09 N08 N09 4.95e+00
C10 N09 Port2 1.38e-12
L10 N09 Port2 2.12e-10
R10 N09 Port2 1.35e+03
.ENDS GRM21A5C2J561FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J561GWA1
* Property : C = 5.60e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J561GWA1 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.77e-10
R03 N02 N03 1.27e-02
C04 N03 N04 8.90e-07
R04 N03 N04 1.67e-02
L05 N04 N05 8.56e-11
R05 N04 N05 3.49e-02
C06 N05 N06 3.64e-09
L06 N05 N06 1.55e-11
R06 N05 N06 4.88e-01
C07 N06 N07 5.93e-10
L07 N06 N07 3.78e-11
R07 N06 N07 1.07e+00
C08 N07 N08 3.24e-10
L08 N07 N08 1.84e-11
R08 N07 N08 4.52e-01
C09 N08 N09 3.66e-12
L09 N08 N09 8.04e-11
R09 N08 N09 4.95e+00
C10 N09 Port2 1.38e-12
L10 N09 Port2 2.12e-10
R10 N09 Port2 1.35e+03
.ENDS GRM21A5C2J561GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-04[uF]/630[V]
* Murata P/N :GRM21A5C2J561JWA1
* Property : C = 5.60e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J561JWA1 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.77e-10
R03 N02 N03 1.27e-02
C04 N03 N04 8.90e-07
R04 N03 N04 1.67e-02
L05 N04 N05 8.56e-11
R05 N04 N05 3.49e-02
C06 N05 N06 3.64e-09
L06 N05 N06 1.55e-11
R06 N05 N06 4.88e-01
C07 N06 N07 5.93e-10
L07 N06 N07 3.78e-11
R07 N06 N07 1.07e+00
C08 N07 N08 3.24e-10
L08 N07 N08 1.84e-11
R08 N07 N08 4.52e-01
C09 N08 N09 3.66e-12
L09 N08 N09 8.04e-11
R09 N08 N09 4.95e+00
C10 N09 Port2 1.38e-12
L10 N09 Port2 2.12e-10
R10 N09 Port2 1.35e+03
.ENDS GRM21A5C2J561JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J680FWA1
* Property : C = 6.80e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J680FWA1 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.77e-10
R03 N02 N03 1.31e-01
L04 N03 N04 1.74e-11
R04 N03 N04 4.23e-01
C05 N04 N05 6.48e-10
L05 N04 N05 7.55e-12
R05 N04 N05 8.06e-01
C06 N05 N06 5.45e-11
L06 N05 N06 3.02e-11
R06 N05 N06 3.69e+00
C07 N06 Port2 2.02e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 3.23e+01
.ENDS GRM21A5C2J680FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J680GWA1
* Property : C = 6.80e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J680GWA1 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.77e-10
R03 N02 N03 1.31e-01
L04 N03 N04 1.74e-11
R04 N03 N04 4.23e-01
C05 N04 N05 6.48e-10
L05 N04 N05 7.55e-12
R05 N04 N05 8.06e-01
C06 N05 N06 5.45e-11
L06 N05 N06 3.02e-11
R06 N05 N06 3.69e+00
C07 N06 Port2 2.02e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 3.23e+01
.ENDS GRM21A5C2J680GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J680JWA1
* Property : C = 6.80e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J680JWA1 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.77e-10
R03 N02 N03 1.31e-01
L04 N03 N04 1.74e-11
R04 N03 N04 4.23e-01
C05 N04 N05 6.48e-10
L05 N04 N05 7.55e-12
R05 N04 N05 8.06e-01
C06 N05 N06 5.45e-11
L06 N05 N06 3.02e-11
R06 N05 N06 3.69e+00
C07 N06 Port2 2.02e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 3.23e+01
.ENDS GRM21A5C2J680JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J820FWA1
* Property : C = 8.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J820FWA1 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.34e-10
R03 N02 N03 1.23e-01
C04 N03 N04 5.15e-08
R04 N03 N04 2.88e-01
C05 N04 N05 4.27e-06
R05 N04 N05 1.75e-03
C06 N05 N06 5.70e-10
L06 N05 N06 1.20e-11
R06 N05 N06 7.27e-01
C07 N06 N07 7.17e-11
L07 N06 N07 3.38e-11
R07 N06 N07 2.68e+00
C08 N07 Port2 1.50e-12
L08 N07 Port2 2.34e-10
R08 N07 Port2 7.54e+01
.ENDS GRM21A5C2J820FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J820GWA1
* Property : C = 8.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J820GWA1 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.34e-10
R03 N02 N03 1.23e-01
C04 N03 N04 5.15e-08
R04 N03 N04 2.88e-01
C05 N04 N05 4.27e-06
R05 N04 N05 1.75e-03
C06 N05 N06 5.70e-10
L06 N05 N06 1.20e-11
R06 N05 N06 7.27e-01
C07 N06 N07 7.17e-11
L07 N06 N07 3.38e-11
R07 N06 N07 2.68e+00
C08 N07 Port2 1.50e-12
L08 N07 Port2 2.34e-10
R08 N07 Port2 7.54e+01
.ENDS GRM21A5C2J820GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-05[uF]/630[V]
* Murata P/N :GRM21A5C2J820JWA1
* Property : C = 8.20e-05[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A5C2J820JWA1 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.34e-10
R03 N02 N03 1.23e-01
C04 N03 N04 5.15e-08
R04 N03 N04 2.88e-01
C05 N04 N05 4.27e-06
R05 N04 N05 1.75e-03
C06 N05 N06 5.70e-10
L06 N05 N06 1.20e-11
R06 N05 N06 7.27e-01
C07 N06 N07 7.17e-11
L07 N06 N07 3.38e-11
R07 N06 N07 2.68e+00
C08 N07 Port2 1.50e-12
L08 N07 Port2 2.34e-10
R08 N07 Port2 7.54e+01
.ENDS GRM21A5C2J820JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GRM21A7U1H333JA39
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U1H333JA39 Port1 Port2
C01 Port1 N01 3.22e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 3.42e-03
L04 N03 N04 1.81e-11
R04 N03 N04 4.91e-01
L05 N04 N05 1.60e-10
R05 N04 N05 1.75e-01
L06 N05 N06 1.32e-10
R06 N05 N06 2.86e-03
C07 N06 N07 1.14e-07
L07 N06 N07 3.95e-11
R07 N06 N07 1.69e-01
C08 N07 N08 7.52e-08
L08 N07 N08 2.79e-11
R08 N07 N08 1.45e-01
C09 N08 N09 1.71e-07
L09 N08 N09 5.36e-12
R09 N08 N09 2.49e-02
C10 N09 N10 1.63e-07
L10 N09 N10 3.74e-12
R10 N09 N10 3.70e-02
C11 N10 N11 1.06e-11
L11 N10 N11 3.32e-11
R11 N10 N11 8.90e+00
C12 N11 Port2 1.04e-12
L12 N11 Port2 2.53e-10
R12 N11 Port2 1.00e+05
.ENDS GRM21A7U1H333JA39
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.00e-04[uF]/250[V]
* Murata P/N :GRM21A7U2E101JW31
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E101JW31 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-11
R03 N02 N03 1.56e-01
C04 N03 N04 2.10e-09
L04 N03 N04 5.91e-12
R04 N03 N04 3.42e-01
C05 N04 N05 1.19e-10
L05 N04 N05 4.12e-11
R05 N04 N05 2.04e+00
C06 N05 N06 4.51e-11
L06 N05 N06 2.89e-11
R06 N05 N06 1.49e+00
C07 N06 Port2 7.96e-13
L07 N06 Port2 6.07e-10
R07 N06 Port2 3.65e+02
.ENDS GRM21A7U2E101JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.00e-03[uF]/250[V]
* Murata P/N :GRM21A7U2E102JW31
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E102JW31 Port1 Port2
C01 Port1 N01 9.93e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.26e-11
R03 N02 N03 2.98e-02
L04 N03 N04 1.30e-10
R04 N03 N04 6.90e-01
C05 N04 N05 7.05e-08
L05 N04 N05 4.64e-11
R05 N04 N05 1.69e-02
C06 N05 N06 2.52e-08
L06 N05 N06 6.15e-12
R06 N05 N06 1.49e-01
C07 N06 N07 2.24e-09
L07 N06 N07 3.25e-11
R07 N06 N07 5.45e-01
C08 N07 Port2 7.56e-13
L08 N07 Port2 4.57e-10
R08 N07 Port2 4.90e+02
.ENDS GRM21A7U2E102JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.20e-04[uF]/250[V]
* Murata P/N :GRM21A7U2E121JW31
* Property : C = 1.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E121JW31 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.22e-11
R03 N02 N03 1.36e-01
L04 N03 N04 1.34e-10
R04 N03 N04 5.29e+00
C05 N04 N05 2.53e-09
L05 N04 N05 6.19e-12
R05 N04 N05 3.66e-01
C06 N05 N06 2.10e-10
L06 N05 N06 3.02e-11
R06 N05 N06 1.55e+00
C07 N06 Port2 8.23e-13
L07 N06 Port2 4.79e-10
R07 N06 Port2 8.25e+02
.ENDS GRM21A7U2E121JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.20e-03[uF]/250[V]
* Murata P/N :GRM21A7U2E122JW31
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E122JW31 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.44e-11
R03 N02 N03 2.16e-02
L04 N03 N04 7.51e-11
R04 N03 N04 4.17e-01
C05 N04 N05 2.43e-08
L05 N04 N05 6.64e-11
R05 N04 N05 2.06e-02
C06 N05 N06 1.35e-08
L06 N05 N06 7.25e-12
R06 N05 N06 1.49e-01
C07 N06 N07 1.54e-09
L07 N06 N07 2.22e-11
R07 N06 N07 4.19e-01
C08 N07 Port2 8.04e-13
L08 N07 Port2 4.50e-10
R08 N07 Port2 5.29e+02
.ENDS GRM21A7U2E122JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.50e-04[uF]/250[V]
* Murata P/N :GRM21A7U2E151JW31
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E151JW31 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.23e-11
R03 N02 N03 1.07e-01
L04 N03 N04 1.21e-10
R04 N03 N04 4.76e+00
C05 N04 N05 1.75e-09
L05 N04 N05 1.20e-11
R05 N04 N05 5.59e-01
C06 N05 N06 2.60e-10
L06 N05 N06 3.67e-11
R06 N05 N06 1.75e+00
C07 N06 Port2 8.80e-13
L07 N06 Port2 4.59e-10
R07 N06 Port2 4.44e+02
.ENDS GRM21A7U2E151JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.50e-03[uF]/250[V]
* Murata P/N :GRM21A7U2E152JW31
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E152JW31 Port1 Port2
C01 Port1 N01 1.49e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 1.65e-02
L04 N03 N04 8.08e-11
R04 N03 N04 7.51e-01
C05 N04 N05 2.27e-08
L05 N04 N05 6.24e-11
R05 N04 N05 2.01e-02
C06 N05 N06 9.51e-09
L06 N05 N06 1.52e-11
R06 N05 N06 2.13e-01
C07 N06 N07 1.54e-09
L07 N06 N07 3.59e-11
R07 N06 N07 4.83e-01
C08 N07 Port2 1.58e-12
L08 N07 Port2 2.20e-10
R08 N07 Port2 2.54e+02
.ENDS GRM21A7U2E152JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.80e-04[uF]/250[V]
* Murata P/N :GRM21A7U2E181JW31
* Property : C = 1.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E181JW31 Port1 Port2
C01 Port1 N01 1.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.74e-12
R03 N02 N03 1.18e-01
L04 N03 N04 1.50e-10
R04 N03 N04 4.79e+00
C05 N04 N05 4.34e-09
L05 N04 N05 5.20e-12
R05 N04 N05 2.18e-01
C06 N05 N06 3.26e-10
L06 N05 N06 2.73e-11
R06 N05 N06 1.08e+00
C07 N06 Port2 9.72e-13
L07 N06 Port2 5.11e-10
R07 N06 Port2 8.79e+02
.ENDS GRM21A7U2E181JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.80e-03[uF]/250[V]
* Murata P/N :GRM21A7U2E182JW31
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E182JW31 Port1 Port2
C01 Port1 N01 1.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.88e-11
R03 N02 N03 1.47e-02
L04 N03 N04 9.24e-11
R04 N03 N04 5.59e-01
C05 N04 N05 3.63e-08
L05 N04 N05 5.44e-11
R05 N04 N05 1.79e-02
C06 N05 N06 1.10e-08
L06 N05 N06 1.68e-11
R06 N05 N06 2.36e-01
C07 N06 N07 2.53e-09
L07 N06 N07 2.88e-11
R07 N06 N07 4.40e-01
C08 N07 Port2 7.22e-13
L08 N07 Port2 3.90e-10
R08 N07 Port2 4.68e+02
.ENDS GRM21A7U2E182JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/2.20e-04[uF]/250[V]
* Murata P/N :GRM21A7U2E221JW31
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E221JW31 Port1 Port2
C01 Port1 N01 2.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.20e-12
R03 N02 N03 1.05e-01
L04 N03 N04 9.55e-11
R04 N03 N04 1.82e+00
C05 N04 N05 3.97e-09
L05 N04 N05 7.57e-12
R05 N04 N05 2.24e-01
C06 N05 N06 3.62e-10
L06 N05 N06 3.59e-11
R06 N05 N06 1.16e+00
C07 N06 Port2 8.44e-13
L07 N06 Port2 5.27e-10
R07 N06 Port2 3.26e+02
.ENDS GRM21A7U2E221JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/2.20e-03[uF]/250[V]
* Murata P/N :GRM21A7U2E222JW31
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E222JW31 Port1 Port2
C01 Port1 N01 2.24e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.95e-11
R03 N02 N03 1.15e-02
L04 N03 N04 9.78e-11
R04 N03 N04 5.26e-01
C05 N04 N05 5.18e-08
L05 N04 N05 5.22e-11
R05 N04 N05 1.65e-02
C06 N05 N06 1.00e-08
L06 N05 N06 2.53e-11
R06 N05 N06 3.24e-01
C07 N06 N07 3.43e-09
L07 N06 N07 3.08e-11
R07 N06 N07 5.35e-01
C08 N07 Port2 1.03e-12
L08 N07 Port2 3.00e-10
R08 N07 Port2 3.59e+02
.ENDS GRM21A7U2E222JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/2.70e-04[uF]/250[V]
* Murata P/N :GRM21A7U2E271JW31
* Property : C = 2.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E271JW31 Port1 Port2
C01 Port1 N01 2.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.18e-12
R03 N02 N03 9.80e-02
L04 N03 N04 1.20e-10
R04 N03 N04 4.61e+00
C05 N04 N05 2.60e-09
L05 N04 N05 1.50e-11
R05 N04 N05 3.90e-01
C06 N05 N06 4.03e-10
L06 N05 N06 4.23e-11
R06 N05 N06 1.26e+00
C07 N06 Port2 1.00e-12
L07 N06 Port2 4.64e-10
R07 N06 Port2 7.19e+02
.ENDS GRM21A7U2E271JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/3.30e-04[uF]/250[V]
* Murata P/N :GRM21A7U2E331JW31
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E331JW31 Port1 Port2
C01 Port1 N01 3.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.17e-12
R03 N02 N03 8.74e-02
L04 N03 N04 1.08e-10
R04 N03 N04 1.38e+00
C05 N04 N05 1.28e-08
L05 N04 N05 3.48e-12
R05 N04 N05 1.12e-01
C06 N05 N06 7.09e-10
L06 N05 N06 2.53e-11
R06 N05 N06 7.14e-01
C07 N06 Port2 7.31e-13
L07 N06 Port2 6.09e-10
R07 N06 Port2 8.58e+02
.ENDS GRM21A7U2E331JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/3.90e-04[uF]/250[V]
* Murata P/N :GRM21A7U2E391JW31
* Property : C = 3.90e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E391JW31 Port1 Port2
C01 Port1 N01 3.90e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.40e-12
R03 N02 N03 8.09e-02
L04 N03 N04 1.04e-10
R04 N03 N04 1.60e+00
C05 N04 N05 6.59e-09
L05 N04 N05 8.25e-12
R05 N04 N05 1.48e-01
C06 N05 N06 6.01e-10
L06 N05 N06 3.96e-11
R06 N05 N06 7.82e-01
C07 N06 Port2 9.21e-13
L07 N06 Port2 5.43e-10
R07 N06 Port2 9.52e+02
.ENDS GRM21A7U2E391JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/4.70e-04[uF]/250[V]
* Murata P/N :GRM21A7U2E471JW31
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E471JW31 Port1 Port2
C01 Port1 N01 4.70e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.04e-11
R03 N02 N03 6.63e-02
L04 N03 N04 8.47e-11
R04 N03 N04 1.31e+00
C05 N04 N05 7.46e-09
L05 N04 N05 9.39e-12
R05 N04 N05 1.89e-01
C06 N05 N06 7.11e-10
L06 N05 N06 4.41e-11
R06 N05 N06 8.32e-01
C07 N06 Port2 9.52e-13
L07 N06 Port2 4.91e-10
R07 N06 Port2 1.27e+03
.ENDS GRM21A7U2E471JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/5.60e-04[uF]/250[V]
* Murata P/N :GRM21A7U2E561JW31
* Property : C = 5.60e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E561JW31 Port1 Port2
C01 Port1 N01 5.60e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 7.43e-11
R03 N02 N03 7.25e-02
L04 N03 N04 9.33e-11
R04 N03 N04 9.61e-01
C05 N04 N05 1.38e-08
L05 N04 N05 5.23e-12
R05 N04 N05 7.15e-02
C06 N05 N06 9.39e-10
L06 N05 N06 3.01e-11
R06 N05 N06 5.21e-01
C07 N06 Port2 8.71e-13
L07 N06 Port2 5.39e-10
R07 N06 Port2 1.67e+03
.ENDS GRM21A7U2E561JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/6.80e-04[uF]/250[V]
* Murata P/N :GRM21A7U2E681JW31
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E681JW31 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-11
R03 N02 N03 6.51e-02
L04 N03 N04 9.60e-11
R04 N03 N04 1.06e+00
C05 N04 N05 1.27e-08
L05 N04 N05 7.59e-12
R05 N04 N05 1.04e-01
C06 N05 N06 1.15e-09
L06 N05 N06 3.62e-11
R06 N05 N06 5.80e-01
C07 N06 Port2 7.36e-13
L07 N06 Port2 6.01e-10
R07 N06 Port2 7.18e+02
.ENDS GRM21A7U2E681JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/8.20e-04[uF]/250[V]
* Murata P/N :GRM21A7U2E821JW31
* Property : C = 8.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21A7U2E821JW31 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.54e-12
R03 N02 N03 5.31e-02
L04 N03 N04 9.77e-11
R04 N03 N04 7.78e-01
C05 N04 N05 1.49e-08
L05 N04 N05 8.44e-12
R05 N04 N05 1.22e-01
C06 N05 N06 1.48e-09
L06 N05 N06 3.77e-11
R06 N05 N06 5.86e-01
C07 N06 Port2 9.01e-13
L07 N06 Port2 5.38e-10
R07 N06 Port2 7.66e+02
.ENDS GRM21A7U2E821JW31
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/1.00e-01[uF]/10[V]
* Murata P/N :GRM21B1X1A104JA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B1X1A104JA01 Port1 Port2
C01 Port1 N01 9.77e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 9.31e-11
R03 N02 N03 3.94e-03
L04 N03 N04 1.84e-11
R04 N03 N04 3.47e-01
L05 N04 N05 1.46e-10
R05 N04 N05 1.08e-01
L06 N05 N06 7.38e-11
R06 N05 N06 2.13e-03
C07 N06 N07 2.06e-07
L07 N06 N07 7.67e-11
R07 N06 N07 1.24e-01
C08 N07 N08 1.71e-07
L08 N07 N08 4.21e-11
R08 N07 N08 8.67e-02
C09 N08 N09 1.96e-07
L09 N08 N09 1.83e-11
R09 N08 N09 3.80e-02
C10 N09 N10 2.62e-07
L10 N09 N10 8.77e-12
R10 N09 N10 3.22e-02
C11 N10 N11 3.65e-11
L11 N10 N11 9.59e-12
R11 N10 N11 1.31e+00
C12 N11 Port2 1.06e-12
L12 N11 Port2 2.05e-10
R12 N11 Port2 1.00e+05
.ENDS GRM21B1X1A104JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/6.80e-02[uF]/10[V]
* Murata P/N :GRM21B1X1A683JA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B1X1A683JA01 Port1 Port2
C01 Port1 N01 6.49e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.57e-11
R03 N02 N03 4.60e-03
L04 N03 N04 1.95e-11
R04 N03 N04 4.22e-01
L05 N04 N05 8.75e-11
R05 N04 N05 1.16e-01
L06 N05 N06 9.66e-11
R06 N05 N06 6.89e-03
C07 N06 N07 2.34e-07
L07 N06 N07 4.00e-11
R07 N06 N07 8.18e-02
C08 N07 N08 8.67e-08
L08 N07 N08 4.56e-11
R08 N07 N08 8.56e-02
C09 N08 N09 5.26e-08
L09 N08 N09 2.40e-11
R09 N08 N09 3.99e-02
C10 N09 N10 1.13e-11
L10 N09 N10 3.11e-11
R10 N09 N10 1.37e+01
C11 N10 Port2 9.00e-13
L11 N10 Port2 3.50e-10
R11 N10 Port2 1.00e+05
.ENDS GRM21B1X1A683JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/8.20e-02[uF]/10[V]
* Murata P/N :GRM21B1X1A823JA01
* Property : C = 8.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B1X1A823JA01 Port1 Port2
C01 Port1 N01 8.39e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.99e-10
R03 N02 N03 3.66e-03
L04 N03 N04 1.54e-10
R04 N03 N04 1.04e-01
L05 N04 N05 9.71e-11
R05 N04 N05 3.25e-03
C06 N05 N06 2.78e-07
L06 N05 N06 4.73e-11
R06 N05 N06 9.82e-02
C07 N06 N07 1.48e-07
L07 N06 N07 4.14e-11
R07 N06 N07 9.16e-02
C08 N07 Port2 1.66e-12
L08 N07 Port2 1.50e-10
R08 N07 Port2 4.52e+01
.ENDS GRM21B1X1A823JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/3.90e-02[uF]/50[V]
* Murata P/N :GRM21B1X1H393JA01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B1X1H393JA01 Port1 Port2
C01 Port1 N01 3.88e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 4.37e-03
L04 N03 N04 9.52e-11
R04 N03 N04 1.71e-01
L05 N04 N05 1.17e-10
R05 N04 N05 5.64e-03
C06 N05 N06 1.12e-07
L06 N05 N06 5.35e-11
R06 N05 N06 1.46e-01
C07 N06 N07 5.11e-08
L07 N06 N07 5.25e-11
R07 N06 N07 1.32e-01
C08 N07 N08 1.78e-07
L08 N07 N08 7.56e-12
R08 N07 N08 3.39e-02
C09 N08 N09 3.84e-08
L09 N08 N09 2.17e-11
R09 N08 N09 6.59e-02
C10 N09 Port2 1.59e-12
L10 N09 Port2 2.00e-10
R10 N09 Port2 4.31e+01
.ENDS GRM21B1X1H393JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/SL(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRM21B1X1H473JA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B1X1H473JA01 Port1 Port2
C01 Port1 N01 4.59e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-11
R03 N02 N03 3.71e-03
L04 N03 N04 2.22e-11
R04 N03 N04 4.19e-01
L05 N04 N05 1.64e-10
R05 N04 N05 1.46e-01
L06 N05 N06 4.84e-11
R06 N05 N06 1.78e-03
C07 N06 N07 1.22e-07
L07 N06 N07 6.18e-11
R07 N06 N07 1.57e-01
C08 N07 N08 8.96e-08
L08 N07 N08 3.82e-11
R08 N07 N08 1.42e-01
C09 N08 N09 2.85e-07
L09 N08 N09 6.74e-12
R09 N08 N09 3.99e-02
C10 N09 N10 1.20e-07
L10 N09 N10 1.01e-11
R10 N09 N10 4.16e-02
C11 N10 N11 4.34e-11
L11 N10 N11 8.09e-12
R11 N10 N11 7.95e-01
C12 N11 Port2 6.06e-13
L12 N11 Port2 2.78e-10
R12 N11 Port2 1.00e+05
.ENDS GRM21B1X1H473JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GRM21B2C1H183JA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B2C1H183JA01 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.81e-11
R03 N02 N03 3.17e-03
L04 N03 N04 1.02e-10
R04 N03 N04 1.98e+01
L05 N04 N05 9.41e-11
R05 N04 N05 1.71e-01
L06 N05 N06 5.48e-11
R06 N05 N06 5.11e-03
L07 N06 N07 1.08e-10
R07 N06 N07 2.19e-03
C08 N07 N08 5.60e-08
L08 N07 N08 4.59e-11
R08 N07 N08 2.70e-01
C09 N08 N09 2.24e-08
L09 N08 N09 4.83e-11
R09 N08 N09 2.65e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.15e-10
R10 N09 Port2 1.00e+05
.ENDS GRM21B2C1H183JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRM21B2C1H223JA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B2C1H223JA01 Port1 Port2
C01 Port1 N01 2.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-11
R03 N02 N03 3.14e-03
L04 N03 N04 1.59e-10
R04 N03 N04 1.73e-01
L05 N04 N05 5.81e-11
R05 N04 N05 3.41e-03
C06 N05 N06 5.16e-08
L06 N05 N06 7.00e-11
R06 N05 N06 2.70e-01
C07 N06 N07 3.75e-08
L07 N06 N07 4.09e-11
R07 N06 N07 2.64e-01
C08 N07 N08 9.41e-08
L08 N07 N08 7.62e-12
R08 N07 N08 6.57e-02
C09 N08 N09 1.05e-07
L09 N08 N09 4.66e-12
R09 N08 N09 1.07e-01
C10 N09 N10 1.83e-11
L10 N09 N10 1.02e-11
R10 N09 N10 2.90e-01
C11 N10 Port2 6.69e-13
L11 N10 Port2 2.76e-10
R11 N10 Port2 1.00e+05
.ENDS GRM21B2C1H223JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GRM21B2C2A183JA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B2C2A183JA01 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.81e-11
R03 N02 N03 3.17e-03
L04 N03 N04 1.02e-10
R04 N03 N04 1.98e+01
L05 N04 N05 9.41e-11
R05 N04 N05 1.71e-01
L06 N05 N06 5.48e-11
R06 N05 N06 5.11e-03
L07 N06 N07 1.08e-10
R07 N06 N07 2.19e-03
C08 N07 N08 5.60e-08
L08 N07 N08 4.59e-11
R08 N07 N08 2.70e-01
C09 N08 N09 2.24e-08
L09 N08 N09 4.83e-11
R09 N08 N09 2.65e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.15e-10
R10 N09 Port2 1.00e+05
.ENDS GRM21B2C2A183JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/CH(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GRM21B2C2A223JA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B2C2A223JA01 Port1 Port2
C01 Port1 N01 2.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-11
R03 N02 N03 3.14e-03
L04 N03 N04 1.59e-10
R04 N03 N04 1.73e-01
L05 N04 N05 5.81e-11
R05 N04 N05 3.41e-03
C06 N05 N06 5.16e-08
L06 N05 N06 7.00e-11
R06 N05 N06 2.70e-01
C07 N06 N07 3.75e-08
L07 N06 N07 4.09e-11
R07 N06 N07 2.64e-01
C08 N07 N08 9.41e-08
L08 N07 N08 7.62e-12
R08 N07 N08 6.57e-02
C09 N08 N09 1.05e-07
L09 N08 N09 4.66e-12
R09 N08 N09 1.07e-01
C10 N09 N10 1.83e-11
L10 N09 N10 1.02e-11
R10 N09 N10 2.90e-01
C11 N10 Port2 6.69e-13
L11 N10 Port2 2.76e-10
R11 N10 Port2 1.00e+05
.ENDS GRM21B2C2A223JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/1.00e-01[uF]/10[V]
* Murata P/N :GRM21B3U1A104JA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B3U1A104JA01 Port1 Port2
C01 Port1 N01 9.77e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 9.31e-11
R03 N02 N03 3.94e-03
L04 N03 N04 1.84e-11
R04 N03 N04 3.47e-01
L05 N04 N05 1.46e-10
R05 N04 N05 1.08e-01
L06 N05 N06 7.38e-11
R06 N05 N06 2.13e-03
C07 N06 N07 2.06e-07
L07 N06 N07 7.67e-11
R07 N06 N07 1.24e-01
C08 N07 N08 1.71e-07
L08 N07 N08 4.21e-11
R08 N07 N08 8.67e-02
C09 N08 N09 1.96e-07
L09 N08 N09 1.83e-11
R09 N08 N09 3.80e-02
C10 N09 N10 2.62e-07
L10 N09 N10 8.77e-12
R10 N09 N10 3.22e-02
C11 N10 N11 3.65e-11
L11 N10 N11 9.59e-12
R11 N10 N11 1.31e+00
C12 N11 Port2 1.06e-12
L12 N11 Port2 2.05e-10
R12 N11 Port2 1.00e+05
.ENDS GRM21B3U1A104JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/6.80e-02[uF]/10[V]
* Murata P/N :GRM21B3U1A683JA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B3U1A683JA01 Port1 Port2
C01 Port1 N01 6.49e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.57e-11
R03 N02 N03 4.60e-03
L04 N03 N04 1.95e-11
R04 N03 N04 4.22e-01
L05 N04 N05 8.75e-11
R05 N04 N05 1.16e-01
L06 N05 N06 9.66e-11
R06 N05 N06 6.89e-03
C07 N06 N07 2.34e-07
L07 N06 N07 4.00e-11
R07 N06 N07 8.18e-02
C08 N07 N08 8.67e-08
L08 N07 N08 4.56e-11
R08 N07 N08 8.56e-02
C09 N08 N09 5.26e-08
L09 N08 N09 2.40e-11
R09 N08 N09 3.99e-02
C10 N09 N10 1.13e-11
L10 N09 N10 3.11e-11
R10 N09 N10 1.37e+01
C11 N10 Port2 9.00e-13
L11 N10 Port2 3.50e-10
R11 N10 Port2 1.00e+05
.ENDS GRM21B3U1A683JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/8.20e-02[uF]/10[V]
* Murata P/N :GRM21B3U1A823JA01
* Property : C = 8.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B3U1A823JA01 Port1 Port2
C01 Port1 N01 8.39e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.99e-10
R03 N02 N03 3.66e-03
L04 N03 N04 1.54e-10
R04 N03 N04 1.04e-01
L05 N04 N05 9.71e-11
R05 N04 N05 3.25e-03
C06 N05 N06 2.78e-07
L06 N05 N06 4.73e-11
R06 N05 N06 9.82e-02
C07 N06 N07 1.48e-07
L07 N06 N07 4.14e-11
R07 N06 N07 9.16e-02
C08 N07 Port2 1.66e-12
L08 N07 Port2 1.50e-10
R08 N07 Port2 4.52e+01
.ENDS GRM21B3U1A823JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/3.90e-02[uF]/50[V]
* Murata P/N :GRM21B3U1H393JA01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B3U1H393JA01 Port1 Port2
C01 Port1 N01 3.88e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 4.37e-03
L04 N03 N04 9.52e-11
R04 N03 N04 1.71e-01
L05 N04 N05 1.17e-10
R05 N04 N05 5.64e-03
C06 N05 N06 1.12e-07
L06 N05 N06 5.35e-11
R06 N05 N06 1.46e-01
C07 N06 N07 5.11e-08
L07 N06 N07 5.25e-11
R07 N06 N07 1.32e-01
C08 N07 N08 1.78e-07
L08 N07 N08 7.56e-12
R08 N07 N08 3.39e-02
C09 N08 N09 3.84e-08
L09 N08 N09 2.17e-11
R09 N08 N09 6.59e-02
C10 N09 Port2 1.59e-12
L10 N09 Port2 2.00e-10
R10 N09 Port2 4.31e+01
.ENDS GRM21B3U1H393JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/UJ(-25to85[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRM21B3U1H473JA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B3U1H473JA01 Port1 Port2
C01 Port1 N01 4.59e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-11
R03 N02 N03 3.71e-03
L04 N03 N04 2.22e-11
R04 N03 N04 4.19e-01
L05 N04 N05 1.64e-10
R05 N04 N05 1.46e-01
L06 N05 N06 4.84e-11
R06 N05 N06 1.78e-03
C07 N06 N07 1.22e-07
L07 N06 N07 6.18e-11
R07 N06 N07 1.57e-01
C08 N07 N08 8.96e-08
L08 N07 N08 3.82e-11
R08 N07 N08 1.42e-01
C09 N08 N09 2.85e-07
L09 N08 N09 6.74e-12
R09 N08 N09 3.99e-02
C10 N09 N10 1.20e-07
L10 N09 N10 1.01e-11
R10 N09 N10 4.16e-02
C11 N10 N11 4.34e-11
L11 N10 N11 8.09e-12
R11 N10 N11 7.95e-01
C12 N11 Port2 6.06e-13
L12 N11 Port2 2.78e-10
R12 N11 Port2 1.00e+05
.ENDS GRM21B3U1H473JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GRM21B5C1H183JA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C1H183JA01 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.81e-11
R03 N02 N03 3.17e-03
L04 N03 N04 1.02e-10
R04 N03 N04 1.98e+01
L05 N04 N05 9.41e-11
R05 N04 N05 1.71e-01
L06 N05 N06 5.48e-11
R06 N05 N06 5.11e-03
L07 N06 N07 1.08e-10
R07 N06 N07 2.19e-03
C08 N07 N08 5.60e-08
L08 N07 N08 4.59e-11
R08 N07 N08 2.70e-01
C09 N08 N09 2.24e-08
L09 N08 N09 4.83e-11
R09 N08 N09 2.65e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.15e-10
R10 N09 Port2 1.00e+05
.ENDS GRM21B5C1H183JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRM21B5C1H223JA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C1H223JA01 Port1 Port2
C01 Port1 N01 2.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-11
R03 N02 N03 3.14e-03
L04 N03 N04 1.59e-10
R04 N03 N04 1.73e-01
L05 N04 N05 5.81e-11
R05 N04 N05 3.41e-03
C06 N05 N06 5.16e-08
L06 N05 N06 7.00e-11
R06 N05 N06 2.70e-01
C07 N06 N07 3.75e-08
L07 N06 N07 4.09e-11
R07 N06 N07 2.64e-01
C08 N07 N08 9.41e-08
L08 N07 N08 7.62e-12
R08 N07 N08 6.57e-02
C09 N08 N09 1.05e-07
L09 N08 N09 4.66e-12
R09 N08 N09 1.07e-01
C10 N09 N10 1.83e-11
L10 N09 N10 1.02e-11
R10 N09 N10 2.90e-01
C11 N10 Port2 6.69e-13
L11 N10 Port2 2.76e-10
R11 N10 Port2 1.00e+05
.ENDS GRM21B5C1H223JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GRM21B5C2A183JA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2A183JA01 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.81e-11
R03 N02 N03 3.17e-03
L04 N03 N04 1.02e-10
R04 N03 N04 1.98e+01
L05 N04 N05 9.41e-11
R05 N04 N05 1.71e-01
L06 N05 N06 5.48e-11
R06 N05 N06 5.11e-03
L07 N06 N07 1.08e-10
R07 N06 N07 2.19e-03
C08 N07 N08 5.60e-08
L08 N07 N08 4.59e-11
R08 N07 N08 2.70e-01
C09 N08 N09 2.24e-08
L09 N08 N09 4.83e-11
R09 N08 N09 2.65e-01
C10 N09 Port2 1.09e-12
L10 N09 Port2 2.15e-10
R10 N09 Port2 1.00e+05
.ENDS GRM21B5C2A183JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GRM21B5C2A223JA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2A223JA01 Port1 Port2
C01 Port1 N01 2.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-11
R03 N02 N03 3.14e-03
L04 N03 N04 1.59e-10
R04 N03 N04 1.73e-01
L05 N04 N05 5.81e-11
R05 N04 N05 3.41e-03
C06 N05 N06 5.16e-08
L06 N05 N06 7.00e-11
R06 N05 N06 2.70e-01
C07 N06 N07 3.75e-08
L07 N06 N07 4.09e-11
R07 N06 N07 2.64e-01
C08 N07 N08 9.41e-08
L08 N07 N08 7.62e-12
R08 N07 N08 6.57e-02
C09 N08 N09 1.05e-07
L09 N08 N09 4.66e-12
R09 N08 N09 1.07e-01
C10 N09 N10 1.83e-11
L10 N09 N10 1.02e-11
R10 N09 N10 2.90e-01
C11 N10 Port2 6.69e-13
L11 N10 Port2 2.76e-10
R11 N10 Port2 1.00e+05
.ENDS GRM21B5C2A223JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-02[uF]/250[V]
* Murata P/N :GRM21B5C2E103FWAA
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E103FWAA Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.98e-10
R03 N02 N03 5.23e-03
C04 N03 N04 1.29e-06
R04 N03 N04 3.45e+00
L05 N04 N05 1.51e-10
R05 N04 N05 3.33e-01
L06 N05 N06 8.00e-11
R06 N05 N06 4.26e-03
C07 N06 N07 2.71e-08
L07 N06 N07 6.08e-11
R07 N06 N07 4.29e-01
C08 N07 N08 1.91e-08
L08 N07 N08 3.93e-11
R08 N07 N08 3.68e-01
C09 N08 N09 7.70e-08
L09 N08 N09 5.01e-12
R09 N08 N09 1.19e-01
C10 N09 Port2 3.49e-08
L10 N09 Port2 7.06e-12
R10 N09 Port2 1.27e-01
.ENDS GRM21B5C2E103FWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-02[uF]/250[V]
* Murata P/N :GRM21B5C2E103GWAA
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E103GWAA Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.98e-10
R03 N02 N03 5.23e-03
C04 N03 N04 1.29e-06
R04 N03 N04 3.45e+00
L05 N04 N05 1.51e-10
R05 N04 N05 3.33e-01
L06 N05 N06 8.00e-11
R06 N05 N06 4.26e-03
C07 N06 N07 2.71e-08
L07 N06 N07 6.08e-11
R07 N06 N07 4.29e-01
C08 N07 N08 1.91e-08
L08 N07 N08 3.93e-11
R08 N07 N08 3.68e-01
C09 N08 N09 7.70e-08
L09 N08 N09 5.01e-12
R09 N08 N09 1.19e-01
C10 N09 Port2 3.49e-08
L10 N09 Port2 7.06e-12
R10 N09 Port2 1.27e-01
.ENDS GRM21B5C2E103GWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-02[uF]/250[V]
* Murata P/N :GRM21B5C2E103JWAA
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E103JWAA Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.98e-10
R03 N02 N03 5.23e-03
C04 N03 N04 1.29e-06
R04 N03 N04 3.45e+00
L05 N04 N05 1.51e-10
R05 N04 N05 3.33e-01
L06 N05 N06 8.00e-11
R06 N05 N06 4.26e-03
C07 N06 N07 2.71e-08
L07 N06 N07 6.08e-11
R07 N06 N07 4.29e-01
C08 N07 N08 1.91e-08
L08 N07 N08 3.93e-11
R08 N07 N08 3.68e-01
C09 N08 N09 7.70e-08
L09 N08 N09 5.01e-12
R09 N08 N09 1.19e-01
C10 N09 Port2 3.49e-08
L10 N09 Port2 7.06e-12
R10 N09 Port2 1.27e-01
.ENDS GRM21B5C2E103JWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E332FWA1
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E332FWA1 Port1 Port2
C01 Port1 N01 3.30e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.07e-11
R03 N02 N03 1.06e-02
C04 N03 N04 1.90e-07
R04 N03 N04 1.82e+01
L05 N04 N05 5.90e-11
R05 N04 N05 3.33e-01
L06 N05 N06 7.46e-11
R06 N05 N06 2.20e-02
C07 N06 N07 2.32e-08
L07 N06 N07 1.82e-11
R07 N06 N07 2.28e-01
C08 N07 N08 5.80e-09
L08 N07 N08 3.04e-11
R08 N07 N08 4.74e-01
C09 N08 N09 4.24e-09
L09 N08 N09 1.27e-11
R09 N08 N09 1.24e-01
C10 N09 Port2 8.49e-13
L10 N09 Port2 4.34e-10
R10 N09 Port2 6.60e+02
.ENDS GRM21B5C2E332FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E332GWA1
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E332GWA1 Port1 Port2
C01 Port1 N01 3.30e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.07e-11
R03 N02 N03 1.06e-02
C04 N03 N04 1.90e-07
R04 N03 N04 1.82e+01
L05 N04 N05 5.90e-11
R05 N04 N05 3.33e-01
L06 N05 N06 7.46e-11
R06 N05 N06 2.20e-02
C07 N06 N07 2.32e-08
L07 N06 N07 1.82e-11
R07 N06 N07 2.28e-01
C08 N07 N08 5.80e-09
L08 N07 N08 3.04e-11
R08 N07 N08 4.74e-01
C09 N08 N09 4.24e-09
L09 N08 N09 1.27e-11
R09 N08 N09 1.24e-01
C10 N09 Port2 8.49e-13
L10 N09 Port2 4.34e-10
R10 N09 Port2 6.60e+02
.ENDS GRM21B5C2E332GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.30e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E332JWA1
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E332JWA1 Port1 Port2
C01 Port1 N01 3.30e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.07e-11
R03 N02 N03 1.06e-02
C04 N03 N04 1.90e-07
R04 N03 N04 1.82e+01
L05 N04 N05 5.90e-11
R05 N04 N05 3.33e-01
L06 N05 N06 7.46e-11
R06 N05 N06 2.20e-02
C07 N06 N07 2.32e-08
L07 N06 N07 1.82e-11
R07 N06 N07 2.28e-01
C08 N07 N08 5.80e-09
L08 N07 N08 3.04e-11
R08 N07 N08 4.74e-01
C09 N08 N09 4.24e-09
L09 N08 N09 1.27e-11
R09 N08 N09 1.24e-01
C10 N09 Port2 8.49e-13
L10 N09 Port2 4.34e-10
R10 N09 Port2 6.60e+02
.ENDS GRM21B5C2E332JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E392FWA1
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E392FWA1 Port1 Port2
C01 Port1 N01 3.90e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.39e-10
R03 N02 N03 9.51e-03
C04 N03 N04 9.40e-08
R04 N03 N04 1.04e+02
L05 N04 N05 7.12e-11
R05 N04 N05 3.05e-01
L06 N05 N06 7.41e-11
R06 N05 N06 1.82e-02
C07 N06 N07 2.55e-08
L07 N06 N07 2.16e-11
R07 N06 N07 2.70e-01
C08 N07 N08 7.38e-09
L08 N07 N08 3.21e-11
R08 N07 N08 4.30e-01
C09 N08 N09 5.94e-09
L09 N08 N09 1.20e-11
R09 N08 N09 1.25e-01
C10 N09 Port2 1.28e-12
L10 N09 Port2 2.51e-10
R10 N09 Port2 2.48e+02
.ENDS GRM21B5C2E392FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E392GWA1
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E392GWA1 Port1 Port2
C01 Port1 N01 3.90e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.39e-10
R03 N02 N03 9.51e-03
C04 N03 N04 9.40e-08
R04 N03 N04 1.04e+02
L05 N04 N05 7.12e-11
R05 N04 N05 3.05e-01
L06 N05 N06 7.41e-11
R06 N05 N06 1.82e-02
C07 N06 N07 2.55e-08
L07 N06 N07 2.16e-11
R07 N06 N07 2.70e-01
C08 N07 N08 7.38e-09
L08 N07 N08 3.21e-11
R08 N07 N08 4.30e-01
C09 N08 N09 5.94e-09
L09 N08 N09 1.20e-11
R09 N08 N09 1.25e-01
C10 N09 Port2 1.28e-12
L10 N09 Port2 2.51e-10
R10 N09 Port2 2.48e+02
.ENDS GRM21B5C2E392GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.90e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E392JWA1
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E392JWA1 Port1 Port2
C01 Port1 N01 3.90e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.39e-10
R03 N02 N03 9.51e-03
C04 N03 N04 9.40e-08
R04 N03 N04 1.04e+02
L05 N04 N05 7.12e-11
R05 N04 N05 3.05e-01
L06 N05 N06 7.41e-11
R06 N05 N06 1.82e-02
C07 N06 N07 2.55e-08
L07 N06 N07 2.16e-11
R07 N06 N07 2.70e-01
C08 N07 N08 7.38e-09
L08 N07 N08 3.21e-11
R08 N07 N08 4.30e-01
C09 N08 N09 5.94e-09
L09 N08 N09 1.20e-11
R09 N08 N09 1.25e-01
C10 N09 Port2 1.28e-12
L10 N09 Port2 2.51e-10
R10 N09 Port2 2.48e+02
.ENDS GRM21B5C2E392JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E472FWA1
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E472FWA1 Port1 Port2
C01 Port1 N01 4.70e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 8.37e-03
C04 N03 N04 1.88e-07
R04 N03 N04 3.89e+01
L05 N04 N05 9.13e-11
R05 N04 N05 4.58e-01
L06 N05 N06 6.23e-11
R06 N05 N06 1.67e-02
C07 N06 N07 2.35e-08
L07 N06 N07 3.00e-11
R07 N06 N07 3.29e-01
C08 N07 N08 9.05e-09
L08 N07 N08 3.48e-11
R08 N07 N08 4.42e-01
C09 N08 N09 4.73e-08
L09 N08 N09 3.29e-12
R09 N08 N09 5.49e-02
C10 N09 N10 1.12e-08
L10 N09 N10 8.98e-12
R10 N09 N10 1.40e-01
C11 N10 Port2 8.81e-13
L11 N10 Port2 3.02e-10
R11 N10 Port2 3.04e+02
.ENDS GRM21B5C2E472FWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E472GWA1
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E472GWA1 Port1 Port2
C01 Port1 N01 4.70e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 8.37e-03
C04 N03 N04 1.88e-07
R04 N03 N04 3.89e+01
L05 N04 N05 9.13e-11
R05 N04 N05 4.58e-01
L06 N05 N06 6.23e-11
R06 N05 N06 1.67e-02
C07 N06 N07 2.35e-08
L07 N06 N07 3.00e-11
R07 N06 N07 3.29e-01
C08 N07 N08 9.05e-09
L08 N07 N08 3.48e-11
R08 N07 N08 4.42e-01
C09 N08 N09 4.73e-08
L09 N08 N09 3.29e-12
R09 N08 N09 5.49e-02
C10 N09 N10 1.12e-08
L10 N09 N10 8.98e-12
R10 N09 N10 1.40e-01
C11 N10 Port2 8.81e-13
L11 N10 Port2 3.02e-10
R11 N10 Port2 3.04e+02
.ENDS GRM21B5C2E472GWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E472JWA1
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E472JWA1 Port1 Port2
C01 Port1 N01 4.70e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 8.37e-03
C04 N03 N04 1.88e-07
R04 N03 N04 3.89e+01
L05 N04 N05 9.13e-11
R05 N04 N05 4.58e-01
L06 N05 N06 6.23e-11
R06 N05 N06 1.67e-02
C07 N06 N07 2.35e-08
L07 N06 N07 3.00e-11
R07 N06 N07 3.29e-01
C08 N07 N08 9.05e-09
L08 N07 N08 3.48e-11
R08 N07 N08 4.42e-01
C09 N08 N09 4.73e-08
L09 N08 N09 3.29e-12
R09 N08 N09 5.49e-02
C10 N09 N10 1.12e-08
L10 N09 N10 8.98e-12
R10 N09 N10 1.40e-01
C11 N10 Port2 8.81e-13
L11 N10 Port2 3.02e-10
R11 N10 Port2 3.04e+02
.ENDS GRM21B5C2E472JWA1
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E562FWAA
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E562FWAA Port1 Port2
C01 Port1 N01 5.60e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.00e-10
R03 N02 N03 4.46e-11
C04 N03 N04 1.71e-07
R04 N03 N04 4.58e+01
L05 N04 N05 6.95e-11
R05 N04 N05 3.06e-01
L06 N05 N06 8.25e-07
R06 N05 N06 1.77e-02
C07 N06 N07 1.64e-08
L07 N06 N07 4.60e-11
R07 N06 N07 3.91e-01
C08 N07 N08 1.07e-08
L08 N07 N08 3.18e-11
R08 N07 N08 4.45e-01
C09 N08 Port2 3.84e-09
L09 N08 Port2 2.89e-11
R09 N08 Port2 1.60e-01
.ENDS GRM21B5C2E562FWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E562GWAA
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E562GWAA Port1 Port2
C01 Port1 N01 5.60e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.00e-10
R03 N02 N03 4.46e-11
C04 N03 N04 1.71e-07
R04 N03 N04 4.58e+01
L05 N04 N05 6.95e-11
R05 N04 N05 3.06e-01
L06 N05 N06 8.25e-07
R06 N05 N06 1.77e-02
C07 N06 N07 1.64e-08
L07 N06 N07 4.60e-11
R07 N06 N07 3.91e-01
C08 N07 N08 1.07e-08
L08 N07 N08 3.18e-11
R08 N07 N08 4.45e-01
C09 N08 Port2 3.84e-09
L09 N08 Port2 2.89e-11
R09 N08 Port2 1.60e-01
.ENDS GRM21B5C2E562GWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.60e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E562JWAA
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E562JWAA Port1 Port2
C01 Port1 N01 5.60e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.00e-10
R03 N02 N03 4.46e-11
C04 N03 N04 1.71e-07
R04 N03 N04 4.58e+01
L05 N04 N05 6.95e-11
R05 N04 N05 3.06e-01
L06 N05 N06 8.25e-07
R06 N05 N06 1.77e-02
C07 N06 N07 1.64e-08
L07 N06 N07 4.60e-11
R07 N06 N07 3.91e-01
C08 N07 N08 1.07e-08
L08 N07 N08 3.18e-11
R08 N07 N08 4.45e-01
C09 N08 Port2 3.84e-09
L09 N08 Port2 2.89e-11
R09 N08 Port2 1.60e-01
.ENDS GRM21B5C2E562JWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E682FWAA
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E682FWAA Port1 Port2
C01 Port1 N01 6.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.24e-10
R03 N02 N03 6.62e-03
C04 N03 N04 5.67e-07
R04 N03 N04 7.01e+00
L05 N04 N05 9.29e-11
R05 N04 N05 6.75e-01
L06 N05 N06 8.26e-11
R06 N05 N06 1.36e-02
C07 N06 N07 2.23e-08
L07 N06 N07 3.98e-11
R07 N06 N07 3.62e-01
C08 N07 N08 1.05e-08
L08 N07 N08 3.60e-11
R08 N07 N08 4.43e-01
C09 N08 Port2 6.09e-09
L09 N08 Port2 1.97e-11
R09 N08 Port2 1.24e-01
.ENDS GRM21B5C2E682FWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E682GWAA
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E682GWAA Port1 Port2
C01 Port1 N01 6.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.24e-10
R03 N02 N03 6.62e-03
C04 N03 N04 5.67e-07
R04 N03 N04 7.01e+00
L05 N04 N05 9.29e-11
R05 N04 N05 6.75e-01
L06 N05 N06 8.26e-11
R06 N05 N06 1.36e-02
C07 N06 N07 2.23e-08
L07 N06 N07 3.98e-11
R07 N06 N07 3.62e-01
C08 N07 N08 1.05e-08
L08 N07 N08 3.60e-11
R08 N07 N08 4.43e-01
C09 N08 Port2 6.09e-09
L09 N08 Port2 1.97e-11
R09 N08 Port2 1.24e-01
.ENDS GRM21B5C2E682GWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E682JWAA
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E682JWAA Port1 Port2
C01 Port1 N01 6.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.24e-10
R03 N02 N03 6.62e-03
C04 N03 N04 5.67e-07
R04 N03 N04 7.01e+00
L05 N04 N05 9.29e-11
R05 N04 N05 6.75e-01
L06 N05 N06 8.26e-11
R06 N05 N06 1.36e-02
C07 N06 N07 2.23e-08
L07 N06 N07 3.98e-11
R07 N06 N07 3.62e-01
C08 N07 N08 1.05e-08
L08 N07 N08 3.60e-11
R08 N07 N08 4.43e-01
C09 N08 Port2 6.09e-09
L09 N08 Port2 1.97e-11
R09 N08 Port2 1.24e-01
.ENDS GRM21B5C2E682JWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E822FWAA
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E822FWAA Port1 Port2
C01 Port1 N01 8.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.81e-10
R03 N02 N03 6.33e-03
C04 N03 N04 1.13e-07
R04 N03 N04 2.21e+01
L05 N04 N05 8.63e-11
R05 N04 N05 3.86e-01
L06 N05 N06 5.32e-11
R06 N05 N06 1.04e-02
C07 N06 N07 2.39e-08
L07 N06 N07 4.84e-11
R07 N06 N07 3.82e-01
C08 N07 N08 1.53e-08
L08 N07 N08 3.28e-11
R08 N07 N08 3.91e-01
C09 N08 Port2 5.24e-09
L09 N08 Port2 3.17e-11
R09 N08 Port2 1.81e-01
.ENDS GRM21B5C2E822FWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E822GWAA
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E822GWAA Port1 Port2
C01 Port1 N01 8.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.81e-10
R03 N02 N03 6.33e-03
C04 N03 N04 1.13e-07
R04 N03 N04 2.21e+01
L05 N04 N05 8.63e-11
R05 N04 N05 3.86e-01
L06 N05 N06 5.32e-11
R06 N05 N06 1.04e-02
C07 N06 N07 2.39e-08
L07 N06 N07 4.84e-11
R07 N06 N07 3.82e-01
C08 N07 N08 1.53e-08
L08 N07 N08 3.28e-11
R08 N07 N08 3.91e-01
C09 N08 Port2 5.24e-09
L09 N08 Port2 3.17e-11
R09 N08 Port2 1.81e-01
.ENDS GRM21B5C2E822GWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-03[uF]/250[V]
* Murata P/N :GRM21B5C2E822JWAA
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2E822JWAA Port1 Port2
C01 Port1 N01 8.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.81e-10
R03 N02 N03 6.33e-03
C04 N03 N04 1.13e-07
R04 N03 N04 2.21e+01
L05 N04 N05 8.63e-11
R05 N04 N05 3.86e-01
L06 N05 N06 5.32e-11
R06 N05 N06 1.04e-02
C07 N06 N07 2.39e-08
L07 N06 N07 4.84e-11
R07 N06 N07 3.82e-01
C08 N07 N08 1.53e-08
L08 N07 N08 3.28e-11
R08 N07 N08 3.91e-01
C09 N08 Port2 5.24e-09
L09 N08 Port2 3.17e-11
R09 N08 Port2 1.81e-01
.ENDS GRM21B5C2E822JWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J102FWA3
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J102FWA3 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 1.43e-03
C04 N03 N04 1.11e-08
R04 N03 N04 5.27e+02
L05 N04 N05 8.07e-11
R05 N04 N05 6.86e-01
L06 N05 N06 1.00e-10
R06 N05 N06 2.87e-02
C07 N06 N07 5.66e-09
L07 N06 N07 2.49e-11
R07 N06 N07 7.31e-01
C08 N07 N08 1.69e-09
L08 N07 N08 3.46e-11
R08 N07 N08 1.06e+00
C09 N08 N09 1.85e-09
L09 N08 N09 9.93e-12
R09 N08 N09 2.83e-01
C10 N09 Port2 8.87e-13
L10 N09 Port2 3.60e-10
R10 N09 Port2 8.16e+02
.ENDS GRM21B5C2J102FWA3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J102GWA3
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J102GWA3 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 1.43e-03
C04 N03 N04 1.11e-08
R04 N03 N04 5.27e+02
L05 N04 N05 8.07e-11
R05 N04 N05 6.86e-01
L06 N05 N06 1.00e-10
R06 N05 N06 2.87e-02
C07 N06 N07 5.66e-09
L07 N06 N07 2.49e-11
R07 N06 N07 7.31e-01
C08 N07 N08 1.69e-09
L08 N07 N08 3.46e-11
R08 N07 N08 1.06e+00
C09 N08 N09 1.85e-09
L09 N08 N09 9.93e-12
R09 N08 N09 2.83e-01
C10 N09 Port2 8.87e-13
L10 N09 Port2 3.60e-10
R10 N09 Port2 8.16e+02
.ENDS GRM21B5C2J102GWA3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.00e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J102JWA3
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J102JWA3 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 1.43e-03
C04 N03 N04 1.11e-08
R04 N03 N04 5.27e+02
L05 N04 N05 8.07e-11
R05 N04 N05 6.86e-01
L06 N05 N06 1.00e-10
R06 N05 N06 2.87e-02
C07 N06 N07 5.66e-09
L07 N06 N07 2.49e-11
R07 N06 N07 7.31e-01
C08 N07 N08 1.69e-09
L08 N07 N08 3.46e-11
R08 N07 N08 1.06e+00
C09 N08 N09 1.85e-09
L09 N08 N09 9.93e-12
R09 N08 N09 2.83e-01
C10 N09 Port2 8.87e-13
L10 N09 Port2 3.60e-10
R10 N09 Port2 8.16e+02
.ENDS GRM21B5C2J102JWA3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J122FWA3
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J122FWA3 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-10
R03 N02 N03 2.88e-03
C04 N03 N04 3.34e-08
R04 N03 N04 8.82e+01
L05 N04 N05 9.12e-11
R05 N04 N05 6.62e-01
L06 N05 N06 8.88e-11
R06 N05 N06 2.47e-02
C07 N06 N07 5.50e-09
L07 N06 N07 3.20e-11
R07 N06 N07 9.02e-01
C08 N07 N08 2.39e-09
L08 N07 N08 3.34e-11
R08 N07 N08 9.93e-01
C09 N08 N09 1.46e-08
L09 N08 N09 2.76e-12
R09 N08 N09 1.62e-01
C10 N09 N10 2.46e-09
L10 N09 N10 1.04e-11
R10 N09 N10 3.15e-01
C11 N10 Port2 1.54e-12
L11 N10 Port2 1.98e-10
R11 N10 Port2 2.20e+02
.ENDS GRM21B5C2J122FWA3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J122GWA3
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J122GWA3 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-10
R03 N02 N03 2.88e-03
C04 N03 N04 3.34e-08
R04 N03 N04 8.82e+01
L05 N04 N05 9.12e-11
R05 N04 N05 6.62e-01
L06 N05 N06 8.88e-11
R06 N05 N06 2.47e-02
C07 N06 N07 5.50e-09
L07 N06 N07 3.20e-11
R07 N06 N07 9.02e-01
C08 N07 N08 2.39e-09
L08 N07 N08 3.34e-11
R08 N07 N08 9.93e-01
C09 N08 N09 1.46e-08
L09 N08 N09 2.76e-12
R09 N08 N09 1.62e-01
C10 N09 N10 2.46e-09
L10 N09 N10 1.04e-11
R10 N09 N10 3.15e-01
C11 N10 Port2 1.54e-12
L11 N10 Port2 1.98e-10
R11 N10 Port2 2.20e+02
.ENDS GRM21B5C2J122GWA3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J122JWA3
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J122JWA3 Port1 Port2
C01 Port1 N01 1.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-10
R03 N02 N03 2.88e-03
C04 N03 N04 3.34e-08
R04 N03 N04 8.82e+01
L05 N04 N05 9.12e-11
R05 N04 N05 6.62e-01
L06 N05 N06 8.88e-11
R06 N05 N06 2.47e-02
C07 N06 N07 5.50e-09
L07 N06 N07 3.20e-11
R07 N06 N07 9.02e-01
C08 N07 N08 2.39e-09
L08 N07 N08 3.34e-11
R08 N07 N08 9.93e-01
C09 N08 N09 1.46e-08
L09 N08 N09 2.76e-12
R09 N08 N09 1.62e-01
C10 N09 N10 2.46e-09
L10 N09 N10 1.04e-11
R10 N09 N10 3.15e-01
C11 N10 Port2 1.54e-12
L11 N10 Port2 1.98e-10
R11 N10 Port2 2.20e+02
.ENDS GRM21B5C2J122JWA3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J152FWAA
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J152FWAA Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.35e-10
R03 N02 N03 4.39e-03
C04 N03 N04 5.19e-08
R04 N03 N04 5.09e+01
L05 N04 N05 8.34e-11
R05 N04 N05 7.53e-01
L06 N05 N06 9.43e-11
R06 N05 N06 2.34e-02
C07 N06 N07 6.39e-09
L07 N06 N07 2.97e-11
R07 N06 N07 9.66e-01
C08 N07 N08 2.39e-09
L08 N07 N08 3.31e-11
R08 N07 N08 1.12e+00
C09 N08 N09 9.83e-09
L09 N08 N09 3.87e-12
R09 N08 N09 1.53e-01
C10 N09 Port2 2.90e-09
L10 N09 Port2 8.10e-12
R10 N09 Port2 2.63e-01
.ENDS GRM21B5C2J152FWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J152GWAA
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J152GWAA Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.35e-10
R03 N02 N03 4.39e-03
C04 N03 N04 5.19e-08
R04 N03 N04 5.09e+01
L05 N04 N05 8.34e-11
R05 N04 N05 7.53e-01
L06 N05 N06 9.43e-11
R06 N05 N06 2.34e-02
C07 N06 N07 6.39e-09
L07 N06 N07 2.97e-11
R07 N06 N07 9.66e-01
C08 N07 N08 2.39e-09
L08 N07 N08 3.31e-11
R08 N07 N08 1.12e+00
C09 N08 N09 9.83e-09
L09 N08 N09 3.87e-12
R09 N08 N09 1.53e-01
C10 N09 Port2 2.90e-09
L10 N09 Port2 8.10e-12
R10 N09 Port2 2.63e-01
.ENDS GRM21B5C2J152GWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J152JWAA
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J152JWAA Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.35e-10
R03 N02 N03 4.39e-03
C04 N03 N04 5.19e-08
R04 N03 N04 5.09e+01
L05 N04 N05 8.34e-11
R05 N04 N05 7.53e-01
L06 N05 N06 9.43e-11
R06 N05 N06 2.34e-02
C07 N06 N07 6.39e-09
L07 N06 N07 2.97e-11
R07 N06 N07 9.66e-01
C08 N07 N08 2.39e-09
L08 N07 N08 3.31e-11
R08 N07 N08 1.12e+00
C09 N08 N09 9.83e-09
L09 N08 N09 3.87e-12
R09 N08 N09 1.53e-01
C10 N09 Port2 2.90e-09
L10 N09 Port2 8.10e-12
R10 N09 Port2 2.63e-01
.ENDS GRM21B5C2J152JWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J182FWAA
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J182FWAA Port1 Port2
C01 Port1 N01 1.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 5.39e-10
R03 N02 N03 2.48e-03
L04 N03 N04 1.35e-10
R04 N03 N04 2.59e-02
C05 N04 N05 1.07e-08
L05 N04 N05 2.84e-04
R05 N04 N05 1.35e+02
C06 N05 N06 4.48e-09
L06 N05 N06 5.76e-11
R06 N05 N06 1.17e+00
C07 N06 N07 2.70e-09
L07 N06 N07 3.97e-11
R07 N06 N07 1.03e+00
C08 N07 N08 3.78e-09
L08 N07 N08 1.43e-11
R08 N07 N08 4.57e-01
C09 N08 Port2 2.03e-09
L09 N08 Port2 1.64e-11
R09 N08 Port2 6.92e-01
.ENDS GRM21B5C2J182FWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J182GWAA
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J182GWAA Port1 Port2
C01 Port1 N01 1.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 5.39e-10
R03 N02 N03 2.48e-03
L04 N03 N04 1.35e-10
R04 N03 N04 2.59e-02
C05 N04 N05 1.07e-08
L05 N04 N05 2.84e-04
R05 N04 N05 1.35e+02
C06 N05 N06 4.48e-09
L06 N05 N06 5.76e-11
R06 N05 N06 1.17e+00
C07 N06 N07 2.70e-09
L07 N06 N07 3.97e-11
R07 N06 N07 1.03e+00
C08 N07 N08 3.78e-09
L08 N07 N08 1.43e-11
R08 N07 N08 4.57e-01
C09 N08 Port2 2.03e-09
L09 N08 Port2 1.64e-11
R09 N08 Port2 6.92e-01
.ENDS GRM21B5C2J182GWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J182JWAA
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J182JWAA Port1 Port2
C01 Port1 N01 1.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 5.39e-10
R03 N02 N03 2.48e-03
L04 N03 N04 1.35e-10
R04 N03 N04 2.59e-02
C05 N04 N05 1.07e-08
L05 N04 N05 2.84e-04
R05 N04 N05 1.35e+02
C06 N05 N06 4.48e-09
L06 N05 N06 5.76e-11
R06 N05 N06 1.17e+00
C07 N06 N07 2.70e-09
L07 N06 N07 3.97e-11
R07 N06 N07 1.03e+00
C08 N07 N08 3.78e-09
L08 N07 N08 1.43e-11
R08 N07 N08 4.57e-01
C09 N08 Port2 2.03e-09
L09 N08 Port2 1.64e-11
R09 N08 Port2 6.92e-01
.ENDS GRM21B5C2J182JWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J222FWAA
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J222FWAA Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 1.52e-03
L04 N03 N04 1.80e-10
R04 N03 N04 2.19e+00
L05 N04 N05 1.16e-10
R05 N04 N05 1.69e-02
C06 N05 N06 4.53e-08
L06 N05 N06 3.51e-04
R06 N05 N06 1.26e+02
C07 N06 N07 6.62e-09
L07 N06 N07 5.05e-11
R07 N06 N07 1.23e+00
C08 N07 N08 3.90e-09
L08 N07 N08 4.03e-11
R08 N07 N08 1.13e+00
C09 N08 N09 8.05e-09
L09 N08 N09 9.90e-12
R09 N08 N09 3.17e-01
C10 N09 Port2 5.08e-09
L10 N09 Port2 9.68e-12
R10 N09 Port2 3.25e-01
.ENDS GRM21B5C2J222FWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J222GWAA
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J222GWAA Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 1.52e-03
L04 N03 N04 1.80e-10
R04 N03 N04 2.19e+00
L05 N04 N05 1.16e-10
R05 N04 N05 1.69e-02
C06 N05 N06 4.53e-08
L06 N05 N06 3.51e-04
R06 N05 N06 1.26e+02
C07 N06 N07 6.62e-09
L07 N06 N07 5.05e-11
R07 N06 N07 1.23e+00
C08 N07 N08 3.90e-09
L08 N07 N08 4.03e-11
R08 N07 N08 1.13e+00
C09 N08 N09 8.05e-09
L09 N08 N09 9.90e-12
R09 N08 N09 3.17e-01
C10 N09 Port2 5.08e-09
L10 N09 Port2 9.68e-12
R10 N09 Port2 3.25e-01
.ENDS GRM21B5C2J222GWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/630[V]
* Murata P/N :GRM21B5C2J222JWAA
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-1000[MHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J222JWAA Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.43e-10
R03 N02 N03 1.52e-03
L04 N03 N04 1.80e-10
R04 N03 N04 2.19e+00
L05 N04 N05 1.16e-10
R05 N04 N05 1.69e-02
C06 N05 N06 4.53e-08
L06 N05 N06 3.51e-04
R06 N05 N06 1.26e+02
C07 N06 N07 6.62e-09
L07 N06 N07 5.05e-11
R07 N06 N07 1.23e+00
C08 N07 N08 3.90e-09
L08 N07 N08 4.03e-11
R08 N07 N08 1.13e+00
C09 N08 N09 8.05e-09
L09 N08 N09 9.90e-12
R09 N08 N09 3.17e-01
C10 N09 Port2 5.08e-09
L10 N09 Port2 9.68e-12
R10 N09 Port2 3.25e-01
.ENDS GRM21B5C2J222JWAA
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-04[uF]/630[V]
* Murata P/N :GRM21B5C2J681FWA3
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J681FWA3 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 2.56e-03
C04 N03 N04 1.58e-06
R04 N03 N04 9.37e-03
C05 N04 N05 5.26e-09
L05 N04 N05 9.52e-11
R05 N04 N05 3.96e-02
C06 N05 N06 3.77e-09
L06 N05 N06 2.12e-11
R06 N05 N06 6.19e-01
C07 N06 N07 1.02e-09
L07 N06 N07 3.06e-11
R07 N06 N07 1.02e+00
C08 N07 N08 4.44e-10
L08 N07 N08 1.97e-11
R08 N07 N08 3.08e-01
C09 N08 N09 8.96e-12
L09 N08 N09 4.51e-11
R09 N08 N09 9.54e-01
C10 N09 Port2 8.53e-13
L10 N09 Port2 3.95e-10
R10 N09 Port2 5.63e+02
.ENDS GRM21B5C2J681FWA3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-04[uF]/630[V]
* Murata P/N :GRM21B5C2J681GWA3
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J681GWA3 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 2.56e-03
C04 N03 N04 1.58e-06
R04 N03 N04 9.37e-03
C05 N04 N05 5.26e-09
L05 N04 N05 9.52e-11
R05 N04 N05 3.96e-02
C06 N05 N06 3.77e-09
L06 N05 N06 2.12e-11
R06 N05 N06 6.19e-01
C07 N06 N07 1.02e-09
L07 N06 N07 3.06e-11
R07 N06 N07 1.02e+00
C08 N07 N08 4.44e-10
L08 N07 N08 1.97e-11
R08 N07 N08 3.08e-01
C09 N08 N09 8.96e-12
L09 N08 N09 4.51e-11
R09 N08 N09 9.54e-01
C10 N09 Port2 8.53e-13
L10 N09 Port2 3.95e-10
R10 N09 Port2 5.63e+02
.ENDS GRM21B5C2J681GWA3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-04[uF]/630[V]
* Murata P/N :GRM21B5C2J681JWA3
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J681JWA3 Port1 Port2
C01 Port1 N01 6.80e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 2.56e-03
C04 N03 N04 1.58e-06
R04 N03 N04 9.37e-03
C05 N04 N05 5.26e-09
L05 N04 N05 9.52e-11
R05 N04 N05 3.96e-02
C06 N05 N06 3.77e-09
L06 N05 N06 2.12e-11
R06 N05 N06 6.19e-01
C07 N06 N07 1.02e-09
L07 N06 N07 3.06e-11
R07 N06 N07 1.02e+00
C08 N07 N08 4.44e-10
L08 N07 N08 1.97e-11
R08 N07 N08 3.08e-01
C09 N08 N09 8.96e-12
L09 N08 N09 4.51e-11
R09 N08 N09 9.54e-01
C10 N09 Port2 8.53e-13
L10 N09 Port2 3.95e-10
R10 N09 Port2 5.63e+02
.ENDS GRM21B5C2J681JWA3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-04[uF]/630[V]
* Murata P/N :GRM21B5C2J821FWA3
* Property : C = 8.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J821FWA3 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.21e-11
R03 N02 N03 3.07e-03
C04 N03 N04 2.07e-07
R04 N03 N04 9.89e-01
L05 N04 N05 5.44e-11
R05 N04 N05 7.94e-01
L06 N05 N06 1.07e-10
R06 N05 N06 3.65e-02
C07 N06 N07 5.12e-09
L07 N06 N07 1.93e-11
R07 N06 N07 5.96e-01
C08 N07 N08 1.21e-09
L08 N07 N08 3.48e-11
R08 N07 N08 1.08e+00
C09 N08 N09 1.09e-08
L09 N08 N09 1.81e-12
R09 N08 N09 8.58e-02
C10 N09 N10 1.10e-09
L10 N09 N10 1.14e-11
R10 N09 N10 3.51e-01
C11 N10 N11 1.63e-09
L11 N10 N11 3.08e-12
R11 N10 N11 1.55e-01
C12 N11 Port2 7.66e-13
L12 N11 Port2 4.41e-10
R12 N11 Port2 4.57e+02
.ENDS GRM21B5C2J821FWA3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-04[uF]/630[V]
* Murata P/N :GRM21B5C2J821GWA3
* Property : C = 8.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J821GWA3 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.21e-11
R03 N02 N03 3.07e-03
C04 N03 N04 2.07e-07
R04 N03 N04 9.89e-01
L05 N04 N05 5.44e-11
R05 N04 N05 7.94e-01
L06 N05 N06 1.07e-10
R06 N05 N06 3.65e-02
C07 N06 N07 5.12e-09
L07 N06 N07 1.93e-11
R07 N06 N07 5.96e-01
C08 N07 N08 1.21e-09
L08 N07 N08 3.48e-11
R08 N07 N08 1.08e+00
C09 N08 N09 1.09e-08
L09 N08 N09 1.81e-12
R09 N08 N09 8.58e-02
C10 N09 N10 1.10e-09
L10 N09 N10 1.14e-11
R10 N09 N10 3.51e-01
C11 N10 N11 1.63e-09
L11 N10 N11 3.08e-12
R11 N10 N11 1.55e-01
C12 N11 Port2 7.66e-13
L12 N11 Port2 4.41e-10
R12 N11 Port2 4.57e+02
.ENDS GRM21B5C2J821GWA3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-04[uF]/630[V]
* Murata P/N :GRM21B5C2J821JWA3
* Property : C = 8.20e-04[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B5C2J821JWA3 Port1 Port2
C01 Port1 N01 8.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.21e-11
R03 N02 N03 3.07e-03
C04 N03 N04 2.07e-07
R04 N03 N04 9.89e-01
L05 N04 N05 5.44e-11
R05 N04 N05 7.94e-01
L06 N05 N06 1.07e-10
R06 N05 N06 3.65e-02
C07 N06 N07 5.12e-09
L07 N06 N07 1.93e-11
R07 N06 N07 5.96e-01
C08 N07 N08 1.21e-09
L08 N07 N08 3.48e-11
R08 N07 N08 1.08e+00
C09 N08 N09 1.09e-08
L09 N08 N09 1.81e-12
R09 N08 N09 8.58e-02
C10 N09 N10 1.10e-09
L10 N09 N10 1.14e-11
R10 N09 N10 3.51e-01
C11 N10 N11 1.63e-09
L11 N10 N11 3.08e-12
R11 N10 N11 1.55e-01
C12 N11 Port2 7.66e-13
L12 N11 Port2 4.41e-10
R12 N11 Port2 4.57e+02
.ENDS GRM21B5C2J821JWA3
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/1.00e-01[uF]/10[V]
* Murata P/N :GRM21B7U1A104JA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B7U1A104JA01 Port1 Port2
C01 Port1 N01 9.77e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 9.31e-11
R03 N02 N03 3.94e-03
L04 N03 N04 1.84e-11
R04 N03 N04 3.47e-01
L05 N04 N05 1.46e-10
R05 N04 N05 1.08e-01
L06 N05 N06 7.38e-11
R06 N05 N06 2.13e-03
C07 N06 N07 2.06e-07
L07 N06 N07 7.67e-11
R07 N06 N07 1.24e-01
C08 N07 N08 1.71e-07
L08 N07 N08 4.21e-11
R08 N07 N08 8.67e-02
C09 N08 N09 1.96e-07
L09 N08 N09 1.83e-11
R09 N08 N09 3.80e-02
C10 N09 N10 2.62e-07
L10 N09 N10 8.77e-12
R10 N09 N10 3.22e-02
C11 N10 N11 3.65e-11
L11 N10 N11 9.59e-12
R11 N10 N11 1.31e+00
C12 N11 Port2 1.06e-12
L12 N11 Port2 2.05e-10
R12 N11 Port2 1.00e+05
.ENDS GRM21B7U1A104JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/6.80e-02[uF]/10[V]
* Murata P/N :GRM21B7U1A683JA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B7U1A683JA01 Port1 Port2
C01 Port1 N01 6.49e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 4.57e-11
R03 N02 N03 4.60e-03
L04 N03 N04 1.95e-11
R04 N03 N04 4.22e-01
L05 N04 N05 8.75e-11
R05 N04 N05 1.16e-01
L06 N05 N06 9.66e-11
R06 N05 N06 6.89e-03
C07 N06 N07 2.34e-07
L07 N06 N07 4.00e-11
R07 N06 N07 8.18e-02
C08 N07 N08 8.67e-08
L08 N07 N08 4.56e-11
R08 N07 N08 8.56e-02
C09 N08 N09 5.26e-08
L09 N08 N09 2.40e-11
R09 N08 N09 3.99e-02
C10 N09 N10 1.13e-11
L10 N09 N10 3.11e-11
R10 N09 N10 1.37e+01
C11 N10 Port2 9.00e-13
L11 N10 Port2 3.50e-10
R11 N10 Port2 1.00e+05
.ENDS GRM21B7U1A683JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/8.20e-02[uF]/10[V]
* Murata P/N :GRM21B7U1A823JA01
* Property : C = 8.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B7U1A823JA01 Port1 Port2
C01 Port1 N01 8.39e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.99e-10
R03 N02 N03 3.66e-03
L04 N03 N04 1.54e-10
R04 N03 N04 1.04e-01
L05 N04 N05 9.71e-11
R05 N04 N05 3.25e-03
C06 N05 N06 2.78e-07
L06 N05 N06 4.73e-11
R06 N05 N06 9.82e-02
C07 N06 N07 1.48e-07
L07 N06 N07 4.14e-11
R07 N06 N07 9.16e-02
C08 N07 Port2 1.66e-12
L08 N07 Port2 1.50e-10
R08 N07 Port2 4.52e+01
.ENDS GRM21B7U1A823JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/3.90e-02[uF]/50[V]
* Murata P/N :GRM21B7U1H393JA01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B7U1H393JA01 Port1 Port2
C01 Port1 N01 3.88e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 4.37e-03
L04 N03 N04 9.52e-11
R04 N03 N04 1.71e-01
L05 N04 N05 1.17e-10
R05 N04 N05 5.64e-03
C06 N05 N06 1.12e-07
L06 N05 N06 5.35e-11
R06 N05 N06 1.46e-01
C07 N06 N07 5.11e-08
L07 N06 N07 5.25e-11
R07 N06 N07 1.32e-01
C08 N07 N08 1.78e-07
L08 N07 N08 7.56e-12
R08 N07 N08 3.39e-02
C09 N08 N09 3.84e-08
L09 N08 N09 2.17e-11
R09 N08 N09 6.59e-02
C10 N09 Port2 1.59e-12
L10 N09 Port2 2.00e-10
R10 N09 Port2 4.31e+01
.ENDS GRM21B7U1H393JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRM21B7U1H473JA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B7U1H473JA01 Port1 Port2
C01 Port1 N01 4.59e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-11
R03 N02 N03 3.71e-03
L04 N03 N04 2.22e-11
R04 N03 N04 4.19e-01
L05 N04 N05 1.64e-10
R05 N04 N05 1.46e-01
L06 N05 N06 4.84e-11
R06 N05 N06 1.78e-03
C07 N06 N07 1.22e-07
L07 N06 N07 6.18e-11
R07 N06 N07 1.57e-01
C08 N07 N08 8.96e-08
L08 N07 N08 3.82e-11
R08 N07 N08 1.42e-01
C09 N08 N09 2.85e-07
L09 N08 N09 6.74e-12
R09 N08 N09 3.99e-02
C10 N09 N10 1.20e-07
L10 N09 N10 1.01e-11
R10 N09 N10 4.16e-02
C11 N10 N11 4.34e-11
L11 N10 N11 8.09e-12
R11 N10 N11 7.95e-01
C12 N11 Port2 6.06e-13
L12 N11 Port2 2.78e-10
R12 N11 Port2 1.00e+05
.ENDS GRM21B7U1H473JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/2.70e-03[uF]/250[V]
* Murata P/N :GRM21B7U2E272JW32
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B7U2E272JW32 Port1 Port2
C01 Port1 N01 2.68e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.11e-11
R03 N02 N03 1.37e-02
L04 N03 N04 7.94e-11
R04 N03 N04 5.24e-01
C05 N04 N05 4.15e-08
L05 N04 N05 5.24e-11
R05 N04 N05 1.66e-02
C06 N05 N06 1.39e-08
L06 N05 N06 2.09e-11
R06 N05 N06 2.19e-01
C07 N06 N07 3.82e-09
L07 N06 N07 3.06e-11
R07 N06 N07 4.20e-01
C08 N07 Port2 8.15e-13
L08 N07 Port2 4.38e-10
R08 N07 Port2 1.29e+03
.ENDS GRM21B7U2E272JW32
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/3.30e-03[uF]/250[V]
* Murata P/N :GRM21B7U2E332JW32
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B7U2E332JW32 Port1 Port2
C01 Port1 N01 3.28e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.36e-10
R03 N02 N03 9.52e-03
L04 N03 N04 8.49e-11
R04 N03 N04 4.89e-01
C05 N04 N05 1.72e-08
L05 N04 N05 2.46e-11
R05 N04 N05 2.66e-01
C06 N05 N06 2.28e-09
L06 N05 N06 8.08e-11
R06 N05 N06 1.83e-02
C07 N06 N07 5.41e-09
L07 N06 N07 3.09e-11
R07 N06 N07 4.35e-01
C08 N07 Port2 1.16e-12
L08 N07 Port2 3.22e-10
R08 N07 Port2 2.40e+02
.ENDS GRM21B7U2E332JW32
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/3.90e-03[uF]/250[V]
* Murata P/N :GRM21B7U2E392JW32
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B7U2E392JW32 Port1 Port2
C01 Port1 N01 3.97e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 8.88e-03
L04 N03 N04 9.87e-11
R04 N03 N04 3.49e-01
C05 N04 N05 9.76e-08
L05 N04 N05 6.14e-11
R05 N04 N05 1.04e-02
C06 N05 N06 1.74e-08
L06 N05 N06 3.03e-11
R06 N05 N06 3.10e-01
C07 N06 N07 7.05e-09
L07 N06 N07 3.17e-11
R07 N06 N07 3.95e-01
C08 N07 Port2 1.19e-12
L08 N07 Port2 2.84e-10
R08 N07 Port2 1.76e+02
.ENDS GRM21B7U2E392JW32
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/4.70e-03[uF]/250[V]
* Murata P/N :GRM21B7U2E472JW32
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B7U2E472JW32 Port1 Port2
C01 Port1 N01 4.69e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 7.82e-03
L04 N03 N04 8.13e-11
R04 N03 N04 4.54e-01
L05 N04 N05 7.02e-11
R05 N04 N05 1.65e-02
C06 N05 N06 2.06e-08
L06 N05 N06 3.31e-11
R06 N05 N06 3.98e-01
C07 N06 N07 6.92e-09
L07 N06 N07 4.49e-11
R07 N06 N07 3.94e-01
C08 N07 Port2 1.69e-12
L08 N07 Port2 2.19e-10
R08 N07 Port2 8.17e+01
.ENDS GRM21B7U2E472JW32
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/U2J(-55to125[deg])/5.60e-03[uF]/250[V]
* Murata P/N :GRM21B7U2E562JW32
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21B7U2E562JW32 Port1 Port2
C01 Port1 N01 5.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.91e-12
R03 N02 N03 6.79e-03
L04 N03 N04 1.42e-10
R04 N03 N04 3.44e-01
C05 N04 N05 1.22e-07
L05 N04 N05 4.15e-11
R05 N04 N05 7.97e-03
C06 N05 N06 2.66e-08
L06 N05 N06 3.08e-11
R06 N05 N06 3.62e-01
C07 N06 N07 9.47e-09
L07 N06 N07 3.81e-11
R07 N06 N07 3.95e-01
C08 N07 Port2 7.42e-13
L08 N07 Port2 3.59e-10
R08 N07 Port2 5.43e+02
.ENDS GRM21B7U2E562JW32
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRM216B31C105KA87
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216B31C105KA87 Port1 Port2
C01 Port1 N01 7.94e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.33e-10
R03 N02 N03 9.79e-03
C04 N03 N04 1.05e-05
R04 N03 N04 6.97e+02
C05 N04 N05 2.52e-05
R05 N04 N05 2.39e+01
C06 N05 N06 2.17e-05
R06 N05 N06 3.59e+00
C07 N06 N07 1.79e-05
R07 N06 N07 5.17e-01
C08 N07 N08 1.49e-05
R08 N07 N08 7.51e-02
C09 N08 N09 1.15e-05
R09 N08 N09 1.51e-02
L10 N09 N10 1.51e-11
R10 N09 N10 8.91e-02
L11 N10 N11 1.08e-10
R11 N10 N11 4.94e-02
C12 N11 N12 4.60e-06
L12 N11 N12 1.16e-11
R12 N11 N12 4.02e-03
C13 N12 N13 3.47e-07
L13 N12 N13 5.98e-11
R13 N12 N13 1.43e-02
C14 N13 N14 1.97e-11
L14 N13 N14 3.97e-11
R14 N13 N14 8.72e+00
C15 N14 Port2 2.56e-12
L15 N14 Port2 1.21e-10
R15 N14 Port2 2.13e+01
.ENDS GRM216B31C105KA87
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRM216B31E105KA75
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216B31E105KA75 Port1 Port2
C01 Port1 N01 7.94e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.33e-10
R03 N02 N03 9.79e-03
C04 N03 N04 1.05e-05
R04 N03 N04 6.97e+02
C05 N04 N05 2.52e-05
R05 N04 N05 2.39e+01
C06 N05 N06 2.17e-05
R06 N05 N06 3.59e+00
C07 N06 N07 1.79e-05
R07 N06 N07 5.17e-01
C08 N07 N08 1.49e-05
R08 N07 N08 7.51e-02
C09 N08 N09 1.15e-05
R09 N08 N09 1.51e-02
L10 N09 N10 1.51e-11
R10 N09 N10 8.91e-02
L11 N10 N11 1.08e-10
R11 N10 N11 4.94e-02
C12 N11 N12 4.60e-06
L12 N11 N12 1.16e-11
R12 N11 N12 4.02e-03
C13 N12 N13 3.47e-07
L13 N12 N13 5.98e-11
R13 N12 N13 1.43e-02
C14 N13 N14 1.97e-11
L14 N13 N14 3.97e-11
R14 N13 N14 8.72e+00
C15 N14 Port2 2.56e-12
L15 N14 Port2 1.21e-10
R15 N14 Port2 2.13e+01
.ENDS GRM216B31E105KA75
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRM216C81C105KA12
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216C81C105KA12 Port1 Port2
C01 Port1 N01 7.71e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.99e-10
R03 N02 N03 9.65e-03
C04 N03 N04 2.49e-05
R04 N03 N04 1.75e+02
C05 N04 N05 2.30e-05
R05 N04 N05 2.19e+01
C06 N05 N06 1.84e-05
R06 N05 N06 2.83e+00
C07 N06 N07 1.63e-05
R07 N06 N07 3.38e-01
C08 N07 N08 1.21e-05
R08 N07 N08 5.11e-02
C09 N08 N09 1.63e-05
R09 N08 N09 5.55e-03
L10 N09 N10 1.60e-11
R10 N09 N10 7.06e-02
L11 N10 N11 9.40e-11
R11 N10 N11 5.16e-02
C12 N11 N12 3.38e-06
L12 N11 N12 1.63e-11
R12 N11 N12 5.34e-03
C13 N12 N13 3.20e-07
L13 N12 N13 6.33e-11
R13 N12 N13 1.74e-02
C14 N13 N14 1.06e-11
L14 N13 N14 7.17e-11
R14 N13 N14 1.02e+01
C15 N14 Port2 1.12e-11
L15 N14 Port2 3.27e-11
R15 N14 Port2 7.12e+00
.ENDS GRM216C81C105KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRM216D71C105KA12
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216D71C105KA12 Port1 Port2
C01 Port1 N01 7.71e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.99e-10
R03 N02 N03 9.65e-03
C04 N03 N04 2.49e-05
R04 N03 N04 1.75e+02
C05 N04 N05 2.30e-05
R05 N04 N05 2.19e+01
C06 N05 N06 1.84e-05
R06 N05 N06 2.83e+00
C07 N06 N07 1.63e-05
R07 N06 N07 3.38e-01
C08 N07 N08 1.21e-05
R08 N07 N08 5.11e-02
C09 N08 N09 1.63e-05
R09 N08 N09 5.55e-03
L10 N09 N10 1.60e-11
R10 N09 N10 7.06e-02
L11 N10 N11 9.40e-11
R11 N10 N11 5.16e-02
C12 N11 N12 3.38e-06
L12 N11 N12 1.63e-11
R12 N11 N12 5.34e-03
C13 N12 N13 3.20e-07
L13 N12 N13 6.33e-11
R13 N12 N13 1.74e-02
C14 N13 N14 1.06e-11
L14 N13 N14 7.17e-11
R14 N13 N14 1.02e+01
C15 N14 Port2 1.12e-11
L15 N14 Port2 3.27e-11
R15 N14 Port2 7.12e+00
.ENDS GRM216D71C105KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRM216D71C105MA12
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216D71C105MA12 Port1 Port2
C01 Port1 N01 7.71e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.99e-10
R03 N02 N03 9.65e-03
C04 N03 N04 2.49e-05
R04 N03 N04 1.75e+02
C05 N04 N05 2.30e-05
R05 N04 N05 2.19e+01
C06 N05 N06 1.84e-05
R06 N05 N06 2.83e+00
C07 N06 N07 1.63e-05
R07 N06 N07 3.38e-01
C08 N07 N08 1.21e-05
R08 N07 N08 5.11e-02
C09 N08 N09 1.63e-05
R09 N08 N09 5.55e-03
L10 N09 N10 1.60e-11
R10 N09 N10 7.06e-02
L11 N10 N11 9.40e-11
R11 N10 N11 5.16e-02
C12 N11 N12 3.38e-06
L12 N11 N12 1.63e-11
R12 N11 N12 5.34e-03
C13 N12 N13 3.20e-07
L13 N12 N13 6.33e-11
R13 N12 N13 1.74e-02
C14 N13 N14 1.06e-11
L14 N13 N14 7.17e-11
R14 N13 N14 1.02e+01
C15 N14 Port2 1.12e-11
L15 N14 Port2 3.27e-11
R15 N14 Port2 7.12e+00
.ENDS GRM216D71C105MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRM216R61C105KA88
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216R61C105KA88 Port1 Port2
C01 Port1 N01 7.94e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.33e-10
R03 N02 N03 9.79e-03
C04 N03 N04 1.05e-05
R04 N03 N04 6.97e+02
C05 N04 N05 2.52e-05
R05 N04 N05 2.39e+01
C06 N05 N06 2.17e-05
R06 N05 N06 3.59e+00
C07 N06 N07 1.79e-05
R07 N06 N07 5.17e-01
C08 N07 N08 1.49e-05
R08 N07 N08 7.51e-02
C09 N08 N09 1.15e-05
R09 N08 N09 1.51e-02
L10 N09 N10 1.51e-11
R10 N09 N10 8.91e-02
L11 N10 N11 1.08e-10
R11 N10 N11 4.94e-02
C12 N11 N12 4.60e-06
L12 N11 N12 1.16e-11
R12 N11 N12 4.02e-03
C13 N12 N13 3.47e-07
L13 N12 N13 5.98e-11
R13 N12 N13 1.43e-02
C14 N13 N14 1.97e-11
L14 N13 N14 3.97e-11
R14 N13 N14 8.72e+00
C15 N14 Port2 2.56e-12
L15 N14 Port2 1.21e-10
R15 N14 Port2 2.13e+01
.ENDS GRM216R61C105KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRM216R61E105KA12
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216R61E105KA12 Port1 Port2
C01 Port1 N01 7.94e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.33e-10
R03 N02 N03 9.79e-03
C04 N03 N04 1.05e-05
R04 N03 N04 6.97e+02
C05 N04 N05 2.52e-05
R05 N04 N05 2.39e+01
C06 N05 N06 2.17e-05
R06 N05 N06 3.59e+00
C07 N06 N07 1.79e-05
R07 N06 N07 5.17e-01
C08 N07 N08 1.49e-05
R08 N07 N08 7.51e-02
C09 N08 N09 1.15e-05
R09 N08 N09 1.51e-02
L10 N09 N10 1.51e-11
R10 N09 N10 8.91e-02
L11 N10 N11 1.08e-10
R11 N10 N11 4.94e-02
C12 N11 N12 4.60e-06
L12 N11 N12 1.16e-11
R12 N11 N12 4.02e-03
C13 N12 N13 3.47e-07
L13 N12 N13 5.98e-11
R13 N12 N13 1.43e-02
C14 N13 N14 1.97e-11
L14 N13 N14 3.97e-11
R14 N13 N14 8.72e+00
C15 N14 Port2 2.56e-12
L15 N14 Port2 1.21e-10
R15 N14 Port2 2.13e+01
.ENDS GRM216R61E105KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRM216R71H103KA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216R71H103KA01 Port1 Port2
C01 Port1 N01 1.01e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 5.79e-02
C04 N03 N04 1.30e-06
R04 N03 N04 2.66e+03
C05 N04 N05 2.09e-06
R05 N04 N05 2.54e+02
C06 N05 N06 1.47e-06
R06 N05 N06 4.85e+01
C07 N06 N07 1.29e-06
R07 N06 N07 5.84e+00
C08 N07 N08 9.31e-07
R08 N07 N08 7.95e-01
C09 N08 N09 4.67e-07
R09 N08 N09 1.37e-01
C10 N09 N10 4.46e-07
R10 N09 N10 1.32e-02
L11 N10 N11 9.41e-11
R11 N10 N11 2.24e-01
C12 N11 N12 2.19e-07
L12 N11 N12 5.18e-12
R12 N11 N12 1.65e-02
C13 N12 N13 2.15e-08
L13 N12 N13 1.55e-11
R13 N12 N13 6.36e-02
C14 N13 N14 8.31e-12
L14 N13 N14 1.67e-10
R14 N13 N14 1.41e+01
C15 N14 Port2 2.53e-12
L15 N14 Port2 1.19e-10
R15 N14 Port2 1.42e+01
.ENDS GRM216R71H103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GRM216R71H123KA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216R71H123KA01 Port1 Port2
C01 Port1 N01 1.27e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.23e-10
R03 N02 N03 5.67e-02
C04 N03 N04 1.34e-06
R04 N03 N04 3.26e+03
C05 N04 N05 2.89e-06
R05 N04 N05 2.16e+02
C06 N05 N06 1.85e-06
R06 N05 N06 5.67e+01
C07 N06 N07 1.61e-06
R07 N06 N07 6.98e+00
C08 N07 N08 1.28e-06
R08 N07 N08 9.42e-01
C09 N08 N09 9.19e-07
R09 N08 N09 1.39e-01
C10 N09 N10 8.45e-07
R10 N09 N10 2.70e-02
L11 N10 N11 5.93e-11
R11 N10 N11 1.96e-01
C12 N11 N12 9.32e-08
L12 N11 N12 1.22e-11
R12 N11 N12 2.71e-02
C13 N12 N13 1.11e-08
L13 N12 N13 3.84e-11
R13 N12 N13 9.63e-02
C14 N13 N14 1.12e-11
L14 N13 N14 1.08e-10
R14 N13 N14 1.17e+01
C15 N14 Port2 1.16e-12
L15 N14 Port2 2.14e-10
R15 N14 Port2 2.43e+01
.ENDS GRM216R71H123KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRM216R71H223KA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216R71H223KA01 Port1 Port2
C01 Port1 N01 2.19e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 3.42e-02
C04 N03 N04 3.11e-06
R04 N03 N04 1.28e+03
C05 N04 N05 4.60e-06
R05 N04 N05 1.17e+02
C06 N05 N06 3.48e-06
R06 N05 N06 1.98e+01
C07 N06 N07 2.85e-06
R07 N06 N07 2.44e+00
C08 N07 N08 2.36e-06
R08 N07 N08 2.95e-01
C09 N08 N09 3.28e-06
R09 N08 N09 5.12e-02
C10 N09 N10 1.10e-06
R10 N09 N10 2.71e-02
L11 N10 N11 9.17e-11
R11 N10 N11 1.99e-01
C12 N11 N12 9.83e-08
L12 N11 N12 1.52e-11
R12 N11 N12 3.15e-02
C13 N12 N13 2.38e-08
L13 N12 N13 2.38e-11
R13 N12 N13 6.31e-02
C14 N13 N14 7.55e-12
L14 N13 N14 1.04e-10
R14 N13 N14 9.71e+00
C15 N14 Port2 2.39e-12
L15 N14 Port2 1.13e-10
R15 N14 Port2 1.90e+01
.ENDS GRM216R71H223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRM216R71H223MA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216R71H223MA01 Port1 Port2
C01 Port1 N01 2.19e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 3.42e-02
C04 N03 N04 3.11e-06
R04 N03 N04 1.28e+03
C05 N04 N05 4.60e-06
R05 N04 N05 1.17e+02
C06 N05 N06 3.48e-06
R06 N05 N06 1.98e+01
C07 N06 N07 2.85e-06
R07 N06 N07 2.44e+00
C08 N07 N08 2.36e-06
R08 N07 N08 2.95e-01
C09 N08 N09 3.28e-06
R09 N08 N09 5.12e-02
C10 N09 N10 1.10e-06
R10 N09 N10 2.71e-02
L11 N10 N11 9.17e-11
R11 N10 N11 1.99e-01
C12 N11 N12 9.83e-08
L12 N11 N12 1.52e-11
R12 N11 N12 3.15e-02
C13 N12 N13 2.38e-08
L13 N12 N13 2.38e-11
R13 N12 N13 6.31e-02
C14 N13 N14 7.55e-12
L14 N13 N14 1.04e-10
R14 N13 N14 9.71e+00
C15 N14 Port2 2.39e-12
L15 N14 Port2 1.13e-10
R15 N14 Port2 1.90e+01
.ENDS GRM216R71H223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GRM216R71H472KA01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216R71H472KA01 Port1 Port2
C01 Port1 N01 4.78e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.43e-10
R03 N02 N03 7.96e-02
C04 N03 N04 5.63e-07
R04 N03 N04 3.63e+03
C05 N04 N05 7.89e-07
R05 N04 N05 2.40e+02
C06 N05 N06 6.64e-07
R06 N05 N06 3.09e+01
C07 N06 N07 4.95e-07
R07 N06 N07 3.41e+00
C08 N07 N08 4.58e-07
R08 N07 N08 4.11e-01
C09 N08 N09 4.50e-07
R09 N08 N09 1.38e-01
C10 N09 N10 8.76e-08
R10 N09 N10 8.56e-02
L11 N10 N11 4.82e-11
R11 N10 N11 2.27e-01
C12 N11 N12 2.41e-08
L12 N11 N12 1.20e-11
R12 N11 N12 6.75e-02
C13 N12 N13 3.03e-09
L13 N12 N13 3.09e-11
R13 N12 N13 1.72e-01
C14 N13 N14 1.15e-11
L14 N13 N14 8.07e-11
R14 N13 N14 9.89e+00
C15 N14 Port2 2.33e-12
L15 N14 Port2 1.39e-10
R15 N14 Port2 2.31e+01
.ENDS GRM216R71H472KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GRM216R71H682KA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM216R71H682KA01 Port1 Port2
C01 Port1 N01 6.74e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.56e-10
R03 N02 N03 7.10e-02
C04 N03 N04 9.27e-07
R04 N03 N04 2.37e+03
C05 N04 N05 1.07e-06
R05 N04 N05 1.93e+02
C06 N05 N06 9.26e-07
R06 N05 N06 2.21e+01
C07 N06 N07 7.52e-07
R07 N06 N07 2.37e+00
C08 N07 N08 4.72e-07
R08 N07 N08 4.00e-01
C09 N08 N09 1.82e-07
R09 N08 N09 8.81e-02
L10 N09 N10 5.82e-11
R10 N09 N10 2.12e-01
C11 N10 N11 8.96e-08
L11 N10 N11 4.98e-12
R11 N10 N11 3.39e-02
C12 N11 N12 6.64e-09
L12 N11 N12 2.45e-11
R12 N11 N12 1.09e-01
C13 N12 N13 1.09e-11
L13 N12 N13 1.21e-10
R13 N12 N13 1.19e+01
C14 N13 Port2 1.93e-12
L14 N13 Port2 1.46e-10
R14 N13 Port2 1.15e+01
.ENDS GRM216R71H682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRM219B11A105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B11A105KA01 Port1 Port2
C01 Port1 N01 9.50e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.71e-10
R03 N02 N03 4.90e-03
C04 N03 N04 1.45e-04
R04 N03 N04 5.41e+00
C05 N04 N05 1.14e-04
R05 N04 N05 7.02e-01
C06 N05 N06 1.09e-04
R06 N05 N06 8.51e-02
C07 N06 N07 7.72e-05
R07 N06 N07 1.11e-02
L08 N07 N08 2.52e-11
R08 N07 N08 5.66e-02
L09 N08 N09 1.79e-10
R09 N08 N09 3.76e-02
C10 N09 N10 4.31e-06
L10 N09 N10 3.29e-11
R10 N09 N10 1.09e-02
C11 N10 N11 1.32e-06
L11 N10 N11 5.10e-11
R11 N10 N11 1.68e-02
C12 N11 N12 1.23e-11
L12 N11 N12 6.03e-11
R12 N11 N12 4.97e+00
C13 N12 Port2 7.26e-12
L13 N12 Port2 4.20e-11
R13 N12 Port2 5.26e+00
.ENDS GRM219B11A105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRM219B11A225KA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B11A225KA01 Port1 Port2
C01 Port1 N01 1.56e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.45e-10
R03 N02 N03 5.32e-03
C04 N03 N04 4.51e-05
R04 N03 N04 3.80e+01
C05 N04 N05 4.43e-05
R05 N04 N05 3.38e+00
C06 N05 N06 3.58e-05
R06 N05 N06 4.36e-01
C07 N06 N07 2.86e-05
R07 N06 N07 5.07e-02
C08 N07 N08 2.24e-05
R08 N07 N08 6.69e-03
L09 N08 N09 1.56e-11
R09 N08 N09 9.46e-02
L10 N09 N10 2.58e-11
R10 N09 N10 3.77e-02
L11 N10 N11 2.08e-10
R11 N10 N11 3.09e-02
C12 N11 N12 4.77e-06
L12 N11 N12 3.91e-11
R12 N11 N12 8.08e-03
C13 N12 N13 2.43e-06
L13 N12 N13 3.45e-11
R13 N12 N13 9.84e-03
C14 N13 N14 1.23e-11
L14 N13 N14 6.64e-11
R14 N13 N14 7.02e+00
C15 N14 Port2 6.42e-12
L15 N14 Port2 4.85e-11
R15 N14 Port2 9.58e+00
.ENDS GRM219B11A225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/6.80e-01[uF]/16[V]
* Murata P/N :GRM219B11C684KA01
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B11C684KA01 Port1 Port2
C01 Port1 N01 6.59e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.69e-10
R03 N02 N03 5.13e-03
C04 N03 N04 9.28e-05
R04 N03 N04 4.29e+01
C05 N04 N05 1.15e-04
R05 N04 N05 6.64e+00
C06 N05 N06 8.87e-05
R06 N05 N06 8.36e-01
C07 N06 N07 8.11e-05
R07 N06 N07 8.11e-02
C08 N07 N08 5.82e-05
R08 N07 N08 1.20e-02
L09 N08 N09 2.56e-11
R09 N08 N09 9.54e-02
L10 N09 N10 1.78e-10
R10 N09 N10 4.46e-02
C11 N10 N11 2.82e-06
L11 N10 N11 3.61e-11
R11 N10 N11 1.40e-02
C12 N11 N12 8.29e-07
L12 N11 N12 5.41e-11
R12 N11 N12 2.05e-02
C13 N12 N13 1.06e-11
L13 N12 N13 5.91e-11
R13 N12 N13 7.37e+00
C14 N13 Port2 6.91e-12
L14 N13 Port2 4.76e-11
R14 N13 Port2 7.77e+00
.ENDS GRM219B11C684KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GRM219B11H333KA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B11H333KA01 Port1 Port2
C01 Port1 N01 3.32e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 2.31e-02
C04 N03 N04 3.49e-06
R04 N03 N04 9.14e+02
C05 N04 N05 5.71e-06
R05 N04 N05 6.04e+01
C06 N05 N06 5.66e-06
R06 N05 N06 8.33e+00
C07 N06 N07 4.77e-06
R07 N06 N07 1.66e+00
C08 N07 N08 4.32e-06
R08 N07 N08 2.71e-01
C09 N08 N09 2.33e-06
R09 N08 N09 7.85e-02
C10 N09 N10 1.34e-06
R10 N09 N10 1.79e-02
L11 N10 N11 1.14e-10
R11 N10 N11 1.59e-01
C12 N11 N12 1.18e-07
L12 N11 N12 3.01e-11
R12 N11 N12 4.36e-02
C13 N12 N13 3.54e-08
L13 N12 N13 3.96e-11
R13 N12 N13 7.16e-02
C14 N13 N14 1.03e-11
L14 N13 N14 7.97e-11
R14 N13 N14 7.47e+00
C15 N14 Port2 2.15e-12
L15 N14 Port2 1.26e-10
R15 N14 Port2 2.36e+01
.ENDS GRM219B11H333KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+01[uF]/4[V]
* Murata P/N :GRM219B30G226ME66
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B30G226ME66 Port1 Port2
C01 Port1 N01 1.62e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.66e-10
R03 N02 N03 2.06e-03
C04 N03 N04 6.32e-04
R04 N03 N04 7.69e+00
C05 N04 N05 8.11e-04
R05 N04 N05 7.63e-01
C06 N05 N06 1.14e-03
R06 N05 N06 6.07e-02
C07 N06 N07 1.17e-03
R07 N06 N07 4.25e-03
L08 N07 N08 1.54e-11
R08 N07 N08 7.88e-02
L09 N08 N09 6.00e-11
R09 N08 N09 3.09e-02
L10 N09 N10 3.49e-10
R10 N09 N10 1.21e-02
C11 N10 N11 9.34e-05
L11 N10 N11 3.73e-11
R11 N10 N11 1.89e-03
C12 N11 N12 3.07e-05
L12 N11 N12 6.20e-11
R12 N11 N12 3.24e-03
C13 N12 N13 1.60e-11
L13 N12 N13 5.23e-11
R13 N12 N13 6.07e+00
C14 N13 Port2 1.04e-11
L14 N13 Port2 2.94e-11
R14 N13 Port2 9.32e+00
.ENDS GRM219B30G226ME66
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM219B30J106KE18
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B30J106KE18 Port1 Port2
C01 Port1 N01 7.34e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 3.04e-03
C04 N03 N04 1.34e-04
R04 N03 N04 4.05e+01
C05 N04 N05 1.96e-04
R05 N04 N05 2.13e+00
C06 N05 N06 1.90e-04
R06 N05 N06 2.23e-01
C07 N06 N07 1.50e-04
R07 N06 N07 2.84e-02
C08 N07 N08 1.19e-04
R08 N07 N08 3.53e-03
L09 N08 N09 1.21e-11
R09 N08 N09 7.97e-02
L10 N09 N10 3.72e-11
R10 N09 N10 3.54e-02
L11 N10 N11 3.03e-10
R11 N10 N11 1.69e-02
C12 N11 N12 1.83e-05
L12 N11 N12 4.93e-11
R12 N11 N12 3.48e-03
C13 N12 N13 1.78e-05
L13 N12 N13 2.60e-11
R13 N12 N13 3.94e-03
C14 N13 N14 7.85e-12
L14 N13 N14 7.54e-11
R14 N13 N14 9.88e+00
C15 N14 Port2 4.57e-12
L15 N14 Port2 5.82e-11
R15 N14 Port2 2.35e+01
.ENDS GRM219B30J106KE18
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM219B30J106ME18
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B30J106ME18 Port1 Port2
C01 Port1 N01 7.34e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 3.04e-03
C04 N03 N04 1.34e-04
R04 N03 N04 4.05e+01
C05 N04 N05 1.96e-04
R05 N04 N05 2.13e+00
C06 N05 N06 1.90e-04
R06 N05 N06 2.23e-01
C07 N06 N07 1.50e-04
R07 N06 N07 2.84e-02
C08 N07 N08 1.19e-04
R08 N07 N08 3.53e-03
L09 N08 N09 1.21e-11
R09 N08 N09 7.97e-02
L10 N09 N10 3.72e-11
R10 N09 N10 3.54e-02
L11 N10 N11 3.03e-10
R11 N10 N11 1.69e-02
C12 N11 N12 1.83e-05
L12 N11 N12 4.93e-11
R12 N11 N12 3.48e-03
C13 N12 N13 1.78e-05
L13 N12 N13 2.60e-11
R13 N12 N13 3.94e-03
C14 N13 N14 7.85e-12
L14 N13 N14 7.54e-11
R14 N13 N14 9.88e+00
C15 N14 Port2 4.57e-12
L15 N14 Port2 5.82e-11
R15 N14 Port2 2.35e+01
.ENDS GRM219B30J106ME18
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRM219B30J226ME47
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B30J226ME47 Port1 Port2
C01 Port1 N01 1.59e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.85e-10
R03 N02 N03 2.19e-03
C04 N03 N04 6.81e-04
R04 N03 N04 7.79e+00
C05 N04 N05 7.22e-04
R05 N04 N05 9.22e-01
C06 N05 N06 1.03e-03
R06 N05 N06 6.64e-02
C07 N06 N07 1.11e-03
R07 N06 N07 4.53e-03
L08 N07 N08 1.39e-11
R08 N07 N08 7.42e-02
L09 N08 N09 5.38e-11
R09 N08 N09 3.23e-02
L10 N09 N10 3.02e-10
R10 N09 N10 1.34e-02
C11 N10 N11 1.18e-05
L11 N10 N11 1.68e-10
R11 N10 N11 4.38e-03
C12 N11 N12 2.05e-11
L12 N11 N12 3.86e-11
R12 N11 N12 4.93e+00
C13 N12 Port2 9.10e-12
L13 N12 Port2 3.16e-11
R13 N12 Port2 4.12e+00
.ENDS GRM219B30J226ME47
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRM219B30J226MEA0
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B30J226MEA0 Port1 Port2
C01 Port1 N01 1.62e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.66e-10
R03 N02 N03 2.06e-03
C04 N03 N04 6.32e-04
R04 N03 N04 7.69e+00
C05 N04 N05 8.11e-04
R05 N04 N05 7.63e-01
C06 N05 N06 1.14e-03
R06 N05 N06 6.07e-02
C07 N06 N07 1.17e-03
R07 N06 N07 4.25e-03
L08 N07 N08 1.54e-11
R08 N07 N08 7.88e-02
L09 N08 N09 6.00e-11
R09 N08 N09 3.09e-02
L10 N09 N10 3.49e-10
R10 N09 N10 1.21e-02
C11 N10 N11 9.34e-05
L11 N10 N11 3.73e-11
R11 N10 N11 1.89e-03
C12 N11 N12 3.07e-05
L12 N11 N12 6.20e-11
R12 N11 N12 3.24e-03
C13 N12 N13 1.60e-11
L13 N12 N13 5.23e-11
R13 N12 N13 6.07e+00
C14 N13 Port2 1.04e-11
L14 N13 Port2 2.94e-11
R14 N13 Port2 9.32e+00
.ENDS GRM219B30J226MEA0
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRM219B30J475KE18
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B30J475KE18 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219B30J475KE18
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM219B31A106KE44
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31A106KE44 Port1 Port2
C01 Port1 N01 7.36e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.12e-10
R03 N02 N03 3.25e-03
C04 N03 N04 1.33e-04
R04 N03 N04 3.31e+01
C05 N04 N05 1.86e-04
R05 N04 N05 1.95e+00
C06 N05 N06 1.89e-04
R06 N05 N06 1.99e-01
C07 N06 N07 1.42e-04
R07 N06 N07 2.63e-02
C08 N07 N08 1.70e-04
R08 N07 N08 3.12e-03
L09 N08 N09 1.22e-11
R09 N08 N09 7.37e-02
L10 N09 N10 3.75e-11
R10 N09 N10 3.26e-02
L11 N10 N11 2.89e-10
R11 N10 N11 1.81e-02
C12 N11 N12 1.93e-05
L12 N11 N12 5.31e-11
R12 N11 N12 3.97e-03
C13 N12 N13 1.48e-05
L13 N12 N13 3.69e-11
R13 N12 N13 4.73e-03
C14 N13 N14 1.26e-11
L14 N13 N14 5.31e-11
R14 N13 N14 5.57e+00
C15 N14 Port2 6.02e-12
L15 N14 Port2 4.80e-11
R15 N14 Port2 2.30e+01
.ENDS GRM219B31A106KE44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM219B31A106ME44
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31A106ME44 Port1 Port2
C01 Port1 N01 7.36e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.12e-10
R03 N02 N03 3.25e-03
C04 N03 N04 1.33e-04
R04 N03 N04 3.31e+01
C05 N04 N05 1.86e-04
R05 N04 N05 1.95e+00
C06 N05 N06 1.89e-04
R06 N05 N06 1.99e-01
C07 N06 N07 1.42e-04
R07 N06 N07 2.63e-02
C08 N07 N08 1.70e-04
R08 N07 N08 3.12e-03
L09 N08 N09 1.22e-11
R09 N08 N09 7.37e-02
L10 N09 N10 3.75e-11
R10 N09 N10 3.26e-02
L11 N10 N11 2.89e-10
R11 N10 N11 1.81e-02
C12 N11 N12 1.93e-05
L12 N11 N12 5.31e-11
R12 N11 N12 3.97e-03
C13 N12 N13 1.48e-05
L13 N12 N13 3.69e-11
R13 N12 N13 4.73e-03
C14 N13 N14 1.26e-11
L14 N13 N14 5.31e-11
R14 N13 N14 5.57e+00
C15 N14 Port2 6.02e-12
L15 N14 Port2 4.80e-11
R15 N14 Port2 2.30e+01
.ENDS GRM219B31A106ME44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRM219B31A226MEA0
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31A226MEA0 Port1 Port2
C01 Port1 N01 1.62e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.66e-10
R03 N02 N03 2.06e-03
C04 N03 N04 6.32e-04
R04 N03 N04 7.69e+00
C05 N04 N05 8.11e-04
R05 N04 N05 7.63e-01
C06 N05 N06 1.14e-03
R06 N05 N06 6.07e-02
C07 N06 N07 1.17e-03
R07 N06 N07 4.25e-03
L08 N07 N08 1.54e-11
R08 N07 N08 7.88e-02
L09 N08 N09 6.00e-11
R09 N08 N09 3.09e-02
L10 N09 N10 3.49e-10
R10 N09 N10 1.21e-02
C11 N10 N11 9.34e-05
L11 N10 N11 3.73e-11
R11 N10 N11 1.89e-03
C12 N11 N12 3.07e-05
L12 N11 N12 6.20e-11
R12 N11 N12 3.24e-03
C13 N12 N13 1.60e-11
L13 N12 N13 5.23e-11
R13 N12 N13 6.07e+00
C14 N13 Port2 1.04e-11
L14 N13 Port2 2.94e-11
R14 N13 Port2 9.32e+00
.ENDS GRM219B31A226MEA0
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM219B31A475KE33
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31A475KE33 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219B31A475KE33
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM219B31A475ME33
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31A475ME33 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219B31A475ME33
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM219B31C106KA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31C106KA73 Port1 Port2
C01 Port1 N01 5.83e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.02e-10
R03 N02 N03 3.34e-03
C04 N03 N04 9.36e-05
R04 N03 N04 4.50e+01
C05 N04 N05 1.59e-04
R05 N04 N05 2.39e+00
C06 N05 N06 1.55e-04
R06 N05 N06 2.51e-01
C07 N06 N07 1.21e-04
R07 N06 N07 3.22e-02
C08 N07 N08 1.18e-04
R08 N07 N08 3.32e-03
L09 N08 N09 1.24e-11
R09 N08 N09 8.21e-02
L10 N09 N10 3.68e-11
R10 N09 N10 3.42e-02
L11 N10 N11 2.44e-10
R11 N10 N11 1.82e-02
C12 N11 N12 1.47e-05
L12 N11 N12 5.57e-11
R12 N11 N12 4.17e-03
C13 N12 N13 7.47e-06
L13 N12 N13 6.06e-11
R13 N12 N13 4.89e-03
C14 N13 N14 1.06e-11
L14 N13 N14 6.40e-11
R14 N13 N14 9.84e+00
C15 N14 Port2 2.73e-12
L15 N14 Port2 1.03e-10
R15 N14 Port2 2.71e+01
.ENDS GRM219B31C106KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM219B31C106MA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31C106MA73 Port1 Port2
C01 Port1 N01 5.83e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.02e-10
R03 N02 N03 3.34e-03
C04 N03 N04 9.36e-05
R04 N03 N04 4.50e+01
C05 N04 N05 1.59e-04
R05 N04 N05 2.39e+00
C06 N05 N06 1.55e-04
R06 N05 N06 2.51e-01
C07 N06 N07 1.21e-04
R07 N06 N07 3.22e-02
C08 N07 N08 1.18e-04
R08 N07 N08 3.32e-03
L09 N08 N09 1.24e-11
R09 N08 N09 8.21e-02
L10 N09 N10 3.68e-11
R10 N09 N10 3.42e-02
L11 N10 N11 2.44e-10
R11 N10 N11 1.82e-02
C12 N11 N12 1.47e-05
L12 N11 N12 5.57e-11
R12 N11 N12 4.17e-03
C13 N12 N13 7.47e-06
L13 N12 N13 6.06e-11
R13 N12 N13 4.89e-03
C14 N13 N14 1.06e-11
L14 N13 N14 6.40e-11
R14 N13 N14 9.84e+00
C15 N14 Port2 2.73e-12
L15 N14 Port2 1.03e-10
R15 N14 Port2 2.71e+01
.ENDS GRM219B31C106MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRM219B31C225KA87
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31C225KA87 Port1 Port2
C01 Port1 N01 1.56e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.45e-10
R03 N02 N03 5.32e-03
C04 N03 N04 4.51e-05
R04 N03 N04 3.80e+01
C05 N04 N05 4.43e-05
R05 N04 N05 3.38e+00
C06 N05 N06 3.58e-05
R06 N05 N06 4.36e-01
C07 N06 N07 2.86e-05
R07 N06 N07 5.07e-02
C08 N07 N08 2.24e-05
R08 N07 N08 6.69e-03
L09 N08 N09 1.56e-11
R09 N08 N09 9.46e-02
L10 N09 N10 2.58e-11
R10 N09 N10 3.77e-02
L11 N10 N11 2.08e-10
R11 N10 N11 3.09e-02
C12 N11 N12 4.77e-06
L12 N11 N12 3.91e-11
R12 N11 N12 8.08e-03
C13 N12 N13 2.43e-06
L13 N12 N13 3.45e-11
R13 N12 N13 9.84e-03
C14 N13 N14 1.23e-11
L14 N13 N14 6.64e-11
R14 N13 N14 7.02e+00
C15 N14 Port2 6.42e-12
L15 N14 Port2 4.85e-11
R15 N14 Port2 9.58e+00
.ENDS GRM219B31C225KA87
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM219B31C475KE15
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31C475KE15 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219B31C475KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRM219B31E105KA88
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31E105KA88 Port1 Port2
C01 Port1 N01 9.74e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.03e-10
R03 N02 N03 5.32e-03
C04 N03 N04 1.24e-05
R04 N03 N04 5.39e+02
C05 N04 N05 8.65e-05
R05 N04 N05 3.04e+00
C06 N05 N06 8.32e-05
R06 N05 N06 2.81e-01
C07 N06 N07 7.06e-05
R07 N06 N07 3.30e-02
C08 N07 N08 6.08e-05
R08 N07 N08 4.82e-03
L09 N08 N09 1.92e-11
R09 N08 N09 6.28e-02
L10 N09 N10 1.82e-10
R10 N09 N10 3.83e-02
C11 N10 N11 3.68e-06
L11 N10 N11 3.66e-11
R11 N10 N11 1.05e-02
C12 N11 N12 1.03e-06
L12 N11 N12 5.72e-11
R12 N11 N12 1.51e-02
C13 N12 N13 9.24e-12
L13 N12 N13 7.76e-11
R13 N12 N13 8.85e+00
C14 N13 Port2 2.46e-12
L14 N13 Port2 1.20e-10
R14 N13 Port2 2.43e+01
.ENDS GRM219B31E105KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM219B31E106KA12
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31E106KA12 Port1 Port2
C01 Port1 N01 6.08e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.65e-10
R03 N02 N03 3.43e-03
C04 N03 N04 1.70e-04
R04 N03 N04 1.99e+01
C05 N04 N05 2.10e-04
R05 N04 N05 1.85e+00
C06 N05 N06 1.96e-04
R06 N05 N06 2.57e-01
C07 N06 N07 1.79e-04
R07 N06 N07 3.29e-02
C08 N07 N08 1.24e-04
R08 N07 N08 5.43e-03
L09 N08 N09 1.61e-11
R09 N08 N09 6.18e-02
L10 N09 N10 3.92e-11
R10 N09 N10 2.49e-02
L11 N10 N11 2.46e-10
R11 N10 N11 1.73e-02
C12 N11 N12 1.90e-05
L12 N11 N12 4.94e-11
R12 N11 N12 3.30e-03
C13 N12 N13 8.65e-06
L13 N12 N13 5.44e-11
R13 N12 N13 5.33e-03
C14 N13 N14 1.41e-11
L14 N13 N14 5.90e-11
R14 N13 N14 7.09e+00
C15 N14 Port2 4.84e-12
L15 N14 Port2 5.30e-11
R15 N14 Port2 1.51e+01
.ENDS GRM219B31E106KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM219B31E106MA12
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31E106MA12 Port1 Port2
C01 Port1 N01 6.08e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.65e-10
R03 N02 N03 3.43e-03
C04 N03 N04 1.70e-04
R04 N03 N04 1.99e+01
C05 N04 N05 2.10e-04
R05 N04 N05 1.85e+00
C06 N05 N06 1.96e-04
R06 N05 N06 2.57e-01
C07 N06 N07 1.79e-04
R07 N06 N07 3.29e-02
C08 N07 N08 1.24e-04
R08 N07 N08 5.43e-03
L09 N08 N09 1.61e-11
R09 N08 N09 6.18e-02
L10 N09 N10 3.92e-11
R10 N09 N10 2.49e-02
L11 N10 N11 2.46e-10
R11 N10 N11 1.73e-02
C12 N11 N12 1.90e-05
L12 N11 N12 4.94e-11
R12 N11 N12 3.30e-03
C13 N12 N13 8.65e-06
L13 N12 N13 5.44e-11
R13 N12 N13 5.33e-03
C14 N13 N14 1.41e-11
L14 N13 N14 5.90e-11
R14 N13 N14 7.09e+00
C15 N14 Port2 4.84e-12
L15 N14 Port2 5.30e-11
R15 N14 Port2 1.51e+01
.ENDS GRM219B31E106MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM219B31E225KA75
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31E225KA75 Port1 Port2
C01 Port1 N01 1.56e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.45e-10
R03 N02 N03 5.32e-03
C04 N03 N04 4.51e-05
R04 N03 N04 3.80e+01
C05 N04 N05 4.43e-05
R05 N04 N05 3.38e+00
C06 N05 N06 3.58e-05
R06 N05 N06 4.36e-01
C07 N06 N07 2.86e-05
R07 N06 N07 5.07e-02
C08 N07 N08 2.24e-05
R08 N07 N08 6.69e-03
L09 N08 N09 1.56e-11
R09 N08 N09 9.46e-02
L10 N09 N10 2.58e-11
R10 N09 N10 3.77e-02
L11 N10 N11 2.08e-10
R11 N10 N11 3.09e-02
C12 N11 N12 4.77e-06
L12 N11 N12 3.91e-11
R12 N11 N12 8.08e-03
C13 N12 N13 2.43e-06
L13 N12 N13 3.45e-11
R13 N12 N13 9.84e-03
C14 N13 N14 1.23e-11
L14 N13 N14 6.64e-11
R14 N13 N14 7.02e+00
C15 N14 Port2 6.42e-12
L15 N14 Port2 4.85e-11
R15 N14 Port2 9.58e+00
.ENDS GRM219B31E225KA75
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM219B31E225MA75
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31E225MA75 Port1 Port2
C01 Port1 N01 1.56e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.45e-10
R03 N02 N03 5.32e-03
C04 N03 N04 4.51e-05
R04 N03 N04 3.80e+01
C05 N04 N05 4.43e-05
R05 N04 N05 3.38e+00
C06 N05 N06 3.58e-05
R06 N05 N06 4.36e-01
C07 N06 N07 2.86e-05
R07 N06 N07 5.07e-02
C08 N07 N08 2.24e-05
R08 N07 N08 6.69e-03
L09 N08 N09 1.56e-11
R09 N08 N09 9.46e-02
L10 N09 N10 2.58e-11
R10 N09 N10 3.77e-02
L11 N10 N11 2.08e-10
R11 N10 N11 3.09e-02
C12 N11 N12 4.77e-06
L12 N11 N12 3.91e-11
R12 N11 N12 8.08e-03
C13 N12 N13 2.43e-06
L13 N12 N13 3.45e-11
R13 N12 N13 9.84e-03
C14 N13 N14 1.23e-11
L14 N13 N14 6.64e-11
R14 N13 N14 7.02e+00
C15 N14 Port2 6.42e-12
L15 N14 Port2 4.85e-11
R15 N14 Port2 9.58e+00
.ENDS GRM219B31E225MA75
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GRM219B31E474KA88
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31E474KA88 Port1 Port2
C01 Port1 N01 4.56e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.78e-10
R03 N02 N03 7.47e-03
C04 N03 N04 6.52e-05
R04 N03 N04 6.75e+01
C05 N04 N05 6.95e-05
R05 N04 N05 1.17e+01
C06 N05 N06 5.83e-05
R06 N05 N06 1.58e+00
C07 N06 N07 5.06e-05
R07 N06 N07 1.80e-01
C08 N07 N08 3.44e-05
R08 N07 N08 2.64e-02
C09 N08 N09 5.42e-05
R09 N08 N09 2.68e-03
L10 N09 N10 1.73e-11
R10 N09 N10 7.49e-02
L11 N10 N11 1.25e-10
R11 N10 N11 4.49e-02
C12 N11 N12 2.25e-06
L12 N11 N12 2.51e-11
R12 N11 N12 1.09e-02
C13 N12 N13 4.42e-07
L13 N12 N13 5.48e-11
R13 N12 N13 2.32e-02
C14 N13 N14 1.21e-11
L14 N13 N14 7.46e-11
R14 N13 N14 8.34e+00
C15 N14 Port2 3.22e-12
L15 N14 Port2 1.07e-10
R15 N14 Port2 2.16e+01
.ENDS GRM219B31E474KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GRM219B31E474MA88
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31E474MA88 Port1 Port2
C01 Port1 N01 4.56e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.78e-10
R03 N02 N03 7.47e-03
C04 N03 N04 6.52e-05
R04 N03 N04 6.75e+01
C05 N04 N05 6.95e-05
R05 N04 N05 1.17e+01
C06 N05 N06 5.83e-05
R06 N05 N06 1.58e+00
C07 N06 N07 5.06e-05
R07 N06 N07 1.80e-01
C08 N07 N08 3.44e-05
R08 N07 N08 2.64e-02
C09 N08 N09 5.42e-05
R09 N08 N09 2.68e-03
L10 N09 N10 1.73e-11
R10 N09 N10 7.49e-02
L11 N10 N11 1.25e-10
R11 N10 N11 4.49e-02
C12 N11 N12 2.25e-06
L12 N11 N12 2.51e-11
R12 N11 N12 1.09e-02
C13 N12 N13 4.42e-07
L13 N12 N13 5.48e-11
R13 N12 N13 2.32e-02
C14 N13 N14 1.21e-11
L14 N13 N14 7.46e-11
R14 N13 N14 8.34e+00
C15 N14 Port2 3.22e-12
L15 N14 Port2 1.07e-10
R15 N14 Port2 2.16e+01
.ENDS GRM219B31E474MA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/6.80e-01[uF]/25[V]
* Murata P/N :GRM219B31E684KA88
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31E684KA88 Port1 Port2
C01 Port1 N01 6.15e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.64e-10
R03 N02 N03 6.73e-03
C04 N03 N04 7.44e-05
R04 N03 N04 5.34e+01
C05 N04 N05 1.24e-04
R05 N04 N05 6.28e+00
C06 N05 N06 8.68e-05
R06 N05 N06 1.41e+00
C07 N06 N07 8.78e-05
R07 N06 N07 2.18e-01
C08 N07 N08 6.26e-05
R08 N07 N08 2.86e-02
C09 N08 N09 6.01e-05
R09 N08 N09 5.79e-03
L10 N09 N10 1.48e-10
R10 N09 N10 4.35e-02
L11 N10 N11 9.95e-12
R11 N10 N11 3.23e-02
C12 N11 N12 3.26e-06
L12 N11 N12 2.47e-11
R12 N11 N12 9.33e-03
C13 N12 N13 6.47e-07
L13 N12 N13 5.28e-11
R13 N12 N13 1.75e-02
C14 N13 N14 1.30e-11
L14 N13 N14 6.67e-11
R14 N13 N14 8.02e+00
C15 N14 Port2 2.55e-12
L15 N14 Port2 1.43e-10
R15 N14 Port2 1.67e+01
.ENDS GRM219B31E684KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRM219B31H105KA73
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31H105KA73 Port1 Port2
C01 Port1 N01 7.28e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.24e-10
R03 N02 N03 7.68e-03
C04 N03 N04 3.18e-05
R04 N03 N04 1.12e+02
C05 N04 N05 3.69e-05
R05 N04 N05 1.71e+01
C06 N05 N06 2.66e-05
R06 N05 N06 3.90e+00
C07 N06 N07 2.09e-05
R07 N06 N07 6.15e-01
C08 N07 N08 2.47e-05
R08 N07 N08 9.50e-02
C09 N08 N09 2.33e-05
R09 N08 N09 3.25e-02
C10 N09 N10 1.19e-05
R10 N09 N10 1.06e-02
L11 N10 N11 2.80e-11
R11 N10 N11 9.75e-02
L12 N11 N12 1.30e-10
R12 N11 N12 3.40e-02
C13 N12 N13 3.00e-06
L13 N12 N13 2.49e-11
R13 N12 N13 8.54e-03
C14 N13 N14 6.98e-07
L14 N13 N14 4.17e-11
R14 N13 N14 1.48e-02
C15 N14 N15 7.98e-12
L15 N14 N15 9.69e-11
R15 N14 N15 1.69e+01
C16 N15 Port2 3.48e-12
L16 N15 Port2 9.69e-11
R16 N15 Port2 1.91e+01
.ENDS GRM219B31H105KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRM219B31H105MA73
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31H105MA73 Port1 Port2
C01 Port1 N01 7.28e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.24e-10
R03 N02 N03 7.68e-03
C04 N03 N04 3.18e-05
R04 N03 N04 1.12e+02
C05 N04 N05 3.69e-05
R05 N04 N05 1.71e+01
C06 N05 N06 2.66e-05
R06 N05 N06 3.90e+00
C07 N06 N07 2.09e-05
R07 N06 N07 6.15e-01
C08 N07 N08 2.47e-05
R08 N07 N08 9.50e-02
C09 N08 N09 2.33e-05
R09 N08 N09 3.25e-02
C10 N09 N10 1.19e-05
R10 N09 N10 1.06e-02
L11 N10 N11 2.80e-11
R11 N10 N11 9.75e-02
L12 N11 N12 1.30e-10
R12 N11 N12 3.40e-02
C13 N12 N13 3.00e-06
L13 N12 N13 2.49e-11
R13 N12 N13 8.54e-03
C14 N13 N14 6.98e-07
L14 N13 N14 4.17e-11
R14 N13 N14 1.48e-02
C15 N14 N15 7.98e-12
L15 N14 N15 9.69e-11
R15 N14 N15 1.69e+01
C16 N15 Port2 3.48e-12
L16 N15 Port2 9.69e-11
R16 N15 Port2 1.91e+01
.ENDS GRM219B31H105MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRM219B31H225KE15
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31H225KE15 Port1 Port2
C01 Port1 N01 1.63e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.14e-10
R03 N02 N03 5.44e-03
C04 N03 N04 7.09e-05
R04 N03 N04 4.76e+01
C05 N04 N05 8.58e-05
R05 N04 N05 5.71e+00
C06 N05 N06 7.10e-05
R06 N05 N06 1.11e+00
C07 N06 N07 6.06e-05
R07 N06 N07 1.85e-01
C08 N07 N08 5.61e-05
R08 N07 N08 3.06e-02
C09 N08 N09 4.37e-05
R09 N08 N09 7.72e-03
L10 N09 N10 8.47e-12
R10 N09 N10 3.99e-02
L11 N10 N11 2.18e-11
R11 N10 N11 3.16e-02
L12 N11 N12 1.64e-10
R12 N11 N12 2.77e-02
C13 N12 N13 5.74e-06
L13 N12 N13 3.51e-11
R13 N12 N13 7.29e-03
C14 N13 N14 2.22e-06
L14 N13 N14 4.25e-11
R14 N13 N14 1.12e-02
C15 N14 Port2 8.18e-12
L15 N14 Port2 7.22e-11
R15 N14 Port2 1.12e+01
.ENDS GRM219B31H225KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRM219B31H225ME15
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31H225ME15 Port1 Port2
C01 Port1 N01 1.63e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.14e-10
R03 N02 N03 5.44e-03
C04 N03 N04 7.09e-05
R04 N03 N04 4.76e+01
C05 N04 N05 8.58e-05
R05 N04 N05 5.71e+00
C06 N05 N06 7.10e-05
R06 N05 N06 1.11e+00
C07 N06 N07 6.06e-05
R07 N06 N07 1.85e-01
C08 N07 N08 5.61e-05
R08 N07 N08 3.06e-02
C09 N08 N09 4.37e-05
R09 N08 N09 7.72e-03
L10 N09 N10 8.47e-12
R10 N09 N10 3.99e-02
L11 N10 N11 2.18e-11
R11 N10 N11 3.16e-02
L12 N11 N12 1.64e-10
R12 N11 N12 2.77e-02
C13 N12 N13 5.74e-06
L13 N12 N13 3.51e-11
R13 N12 N13 7.29e-03
C14 N13 N14 2.22e-06
L14 N13 N14 4.25e-11
R14 N13 N14 1.12e-02
C15 N14 Port2 8.18e-12
L15 N14 Port2 7.22e-11
R15 N14 Port2 1.12e+01
.ENDS GRM219B31H225ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/3.30e-01[uF]/50[V]
* Murata P/N :GRM219B31H334KA87
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31H334KA87 Port1 Port2
C01 Port1 N01 3.06e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.52e-10
R03 N02 N03 8.62e-03
C04 N03 N04 2.34e-05
R04 N03 N04 9.30e-02
C05 N04 N05 2.25e-05
R05 N04 N05 1.48e-02
L06 N05 N06 1.21e-11
R06 N05 N06 7.25e-02
L07 N06 N07 9.62e-11
R07 N06 N07 6.05e-02
C08 N07 N08 1.35e-06
L08 N07 N08 2.81e-11
R08 N07 N08 1.79e-02
C09 N08 N09 2.18e-07
L09 N08 N09 7.54e-11
R09 N08 N09 3.32e-02
C10 N09 N10 8.22e-12
L10 N09 N10 9.52e-11
R10 N09 N10 1.15e+01
C11 N10 Port2 4.97e-12
L11 N10 Port2 7.35e-11
R11 N10 Port2 1.13e+01
.ENDS GRM219B31H334KA87
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/3.30e-01[uF]/50[V]
* Murata P/N :GRM219B31H334MA87
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219B31H334MA87 Port1 Port2
C01 Port1 N01 3.06e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.52e-10
R03 N02 N03 8.62e-03
C04 N03 N04 2.34e-05
R04 N03 N04 9.30e-02
C05 N04 N05 2.25e-05
R05 N04 N05 1.48e-02
L06 N05 N06 1.21e-11
R06 N05 N06 7.25e-02
L07 N06 N07 9.62e-11
R07 N06 N07 6.05e-02
C08 N07 N08 1.35e-06
L08 N07 N08 2.81e-11
R08 N07 N08 1.79e-02
C09 N08 N09 2.18e-07
L09 N08 N09 7.54e-11
R09 N08 N09 3.32e-02
C10 N09 N10 8.22e-12
L10 N09 N10 9.52e-11
R10 N09 N10 1.15e+01
C11 N10 Port2 4.97e-12
L11 N10 Port2 7.35e-11
R11 N10 Port2 1.13e+01
.ENDS GRM219B31H334MA87
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/4[V]
* Murata P/N :GRM219C80G106KE19
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C80G106KE19 Port1 Port2
C01 Port1 N01 7.34e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 3.04e-03
C04 N03 N04 1.34e-04
R04 N03 N04 4.05e+01
C05 N04 N05 1.96e-04
R05 N04 N05 2.13e+00
C06 N05 N06 1.90e-04
R06 N05 N06 2.23e-01
C07 N06 N07 1.50e-04
R07 N06 N07 2.84e-02
C08 N07 N08 1.19e-04
R08 N07 N08 3.53e-03
L09 N08 N09 1.21e-11
R09 N08 N09 7.97e-02
L10 N09 N10 3.72e-11
R10 N09 N10 3.54e-02
L11 N10 N11 3.03e-10
R11 N10 N11 1.69e-02
C12 N11 N12 1.83e-05
L12 N11 N12 4.93e-11
R12 N11 N12 3.48e-03
C13 N12 N13 1.78e-05
L13 N12 N13 2.60e-11
R13 N12 N13 3.94e-03
C14 N13 N14 7.85e-12
L14 N13 N14 7.54e-11
R14 N13 N14 9.88e+00
C15 N14 Port2 4.57e-12
L15 N14 Port2 5.82e-11
R15 N14 Port2 2.35e+01
.ENDS GRM219C80G106KE19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/4[V]
* Murata P/N :GRM219C80G106ME19
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C80G106ME19 Port1 Port2
C01 Port1 N01 7.34e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 3.04e-03
C04 N03 N04 1.34e-04
R04 N03 N04 4.05e+01
C05 N04 N05 1.96e-04
R05 N04 N05 2.13e+00
C06 N05 N06 1.90e-04
R06 N05 N06 2.23e-01
C07 N06 N07 1.50e-04
R07 N06 N07 2.84e-02
C08 N07 N08 1.19e-04
R08 N07 N08 3.53e-03
L09 N08 N09 1.21e-11
R09 N08 N09 7.97e-02
L10 N09 N10 3.72e-11
R10 N09 N10 3.54e-02
L11 N10 N11 3.03e-10
R11 N10 N11 1.69e-02
C12 N11 N12 1.83e-05
L12 N11 N12 4.93e-11
R12 N11 N12 3.48e-03
C13 N12 N13 1.78e-05
L13 N12 N13 2.60e-11
R13 N12 N13 3.94e-03
C14 N13 N14 7.85e-12
L14 N13 N14 7.54e-11
R14 N13 N14 9.88e+00
C15 N14 Port2 4.57e-12
L15 N14 Port2 5.82e-11
R15 N14 Port2 2.35e+01
.ENDS GRM219C80G106ME19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM219C80J106KE39
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C80J106KE39 Port1 Port2
C01 Port1 N01 7.36e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.12e-10
R03 N02 N03 3.25e-03
C04 N03 N04 1.33e-04
R04 N03 N04 3.31e+01
C05 N04 N05 1.86e-04
R05 N04 N05 1.95e+00
C06 N05 N06 1.89e-04
R06 N05 N06 1.99e-01
C07 N06 N07 1.42e-04
R07 N06 N07 2.63e-02
C08 N07 N08 1.70e-04
R08 N07 N08 3.12e-03
L09 N08 N09 1.22e-11
R09 N08 N09 7.37e-02
L10 N09 N10 3.75e-11
R10 N09 N10 3.26e-02
L11 N10 N11 2.89e-10
R11 N10 N11 1.81e-02
C12 N11 N12 1.93e-05
L12 N11 N12 5.31e-11
R12 N11 N12 3.97e-03
C13 N12 N13 1.48e-05
L13 N12 N13 3.69e-11
R13 N12 N13 4.73e-03
C14 N13 N14 1.26e-11
L14 N13 N14 5.31e-11
R14 N13 N14 5.57e+00
C15 N14 Port2 6.02e-12
L15 N14 Port2 4.80e-11
R15 N14 Port2 2.30e+01
.ENDS GRM219C80J106KE39
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM219C80J106ME39
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C80J106ME39 Port1 Port2
C01 Port1 N01 7.36e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.12e-10
R03 N02 N03 3.25e-03
C04 N03 N04 1.33e-04
R04 N03 N04 3.31e+01
C05 N04 N05 1.86e-04
R05 N04 N05 1.95e+00
C06 N05 N06 1.89e-04
R06 N05 N06 1.99e-01
C07 N06 N07 1.42e-04
R07 N06 N07 2.63e-02
C08 N07 N08 1.70e-04
R08 N07 N08 3.12e-03
L09 N08 N09 1.22e-11
R09 N08 N09 7.37e-02
L10 N09 N10 3.75e-11
R10 N09 N10 3.26e-02
L11 N10 N11 2.89e-10
R11 N10 N11 1.81e-02
C12 N11 N12 1.93e-05
L12 N11 N12 5.31e-11
R12 N11 N12 3.97e-03
C13 N12 N13 1.48e-05
L13 N12 N13 3.69e-11
R13 N12 N13 4.73e-03
C14 N13 N14 1.26e-11
L14 N13 N14 5.31e-11
R14 N13 N14 5.57e+00
C15 N14 Port2 6.02e-12
L15 N14 Port2 4.80e-11
R15 N14 Port2 2.30e+01
.ENDS GRM219C80J106ME39
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRM219C80J475KE19
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C80J475KE19 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219C80J475KE19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM219C81A475KE34
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C81A475KE34 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219C81A475KE34
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM219C81A475ME34
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C81A475ME34 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219C81A475ME34
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRM219C81C225KA12
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C81C225KA12 Port1 Port2
C01 Port1 N01 1.56e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.45e-10
R03 N02 N03 5.32e-03
C04 N03 N04 4.51e-05
R04 N03 N04 3.80e+01
C05 N04 N05 4.43e-05
R05 N04 N05 3.38e+00
C06 N05 N06 3.58e-05
R06 N05 N06 4.36e-01
C07 N06 N07 2.86e-05
R07 N06 N07 5.07e-02
C08 N07 N08 2.24e-05
R08 N07 N08 6.69e-03
L09 N08 N09 1.56e-11
R09 N08 N09 9.46e-02
L10 N09 N10 2.58e-11
R10 N09 N10 3.77e-02
L11 N10 N11 2.08e-10
R11 N10 N11 3.09e-02
C12 N11 N12 4.77e-06
L12 N11 N12 3.91e-11
R12 N11 N12 8.08e-03
C13 N12 N13 2.43e-06
L13 N12 N13 3.45e-11
R13 N12 N13 9.84e-03
C14 N13 N14 1.23e-11
L14 N13 N14 6.64e-11
R14 N13 N14 7.02e+00
C15 N14 Port2 6.42e-12
L15 N14 Port2 4.85e-11
R15 N14 Port2 9.58e+00
.ENDS GRM219C81C225KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM219C81C475KA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C81C475KA73 Port1 Port2
C01 Port1 N01 3.27e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.92e-10
R03 N02 N03 4.43e-03
C04 N03 N04 1.23e-04
R04 N03 N04 4.01e+01
C05 N04 N05 1.06e-04
R05 N04 N05 5.06e+00
C06 N05 N06 1.09e-04
R06 N05 N06 5.46e-01
C07 N06 N07 9.37e-05
R07 N06 N07 6.93e-02
C08 N07 N08 7.43e-05
R08 N07 N08 1.07e-02
L09 N08 N09 2.04e-11
R09 N08 N09 6.68e-02
L10 N09 N10 1.74e-10
R10 N09 N10 2.31e-02
L11 N10 N11 1.47e-11
R11 N10 N11 8.68e-03
C12 N11 N12 1.98e-05
L12 N11 N12 2.35e-11
R12 N11 N12 3.39e-03
C13 N12 N13 2.62e-06
L13 N12 N13 7.79e-11
R13 N12 N13 9.43e-03
C14 N13 N14 1.44e-11
L14 N13 N14 5.75e-11
R14 N13 N14 9.02e+00
C15 N14 Port2 8.28e-12
L15 N14 Port2 3.82e-11
R15 N14 Port2 1.06e+01
.ENDS GRM219C81C475KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM219C81C475MA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C81C475MA73 Port1 Port2
C01 Port1 N01 3.27e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.92e-10
R03 N02 N03 4.43e-03
C04 N03 N04 1.23e-04
R04 N03 N04 4.01e+01
C05 N04 N05 1.06e-04
R05 N04 N05 5.06e+00
C06 N05 N06 1.09e-04
R06 N05 N06 5.46e-01
C07 N06 N07 9.37e-05
R07 N06 N07 6.93e-02
C08 N07 N08 7.43e-05
R08 N07 N08 1.07e-02
L09 N08 N09 2.04e-11
R09 N08 N09 6.68e-02
L10 N09 N10 1.74e-10
R10 N09 N10 2.31e-02
L11 N10 N11 1.47e-11
R11 N10 N11 8.68e-03
C12 N11 N12 1.98e-05
L12 N11 N12 2.35e-11
R12 N11 N12 3.39e-03
C13 N12 N13 2.62e-06
L13 N12 N13 7.79e-11
R13 N12 N13 9.43e-03
C14 N13 N14 1.44e-11
L14 N13 N14 5.75e-11
R14 N13 N14 9.02e+00
C15 N14 Port2 8.28e-12
L15 N14 Port2 3.82e-11
R15 N14 Port2 1.06e+01
.ENDS GRM219C81C475MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM219C81E225KE15
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C81E225KE15 Port1 Port2
C01 Port1 N01 1.58e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.76e-10
R03 N02 N03 5.55e-03
C04 N03 N04 7.50e-05
R04 N03 N04 6.37e+01
C05 N04 N05 9.43e-05
R05 N04 N05 7.16e+00
C06 N05 N06 6.36e-05
R06 N05 N06 1.45e+00
C07 N06 N07 6.30e-05
R07 N06 N07 1.80e-01
C08 N07 N08 5.15e-05
R08 N07 N08 3.38e-02
C09 N08 N09 5.38e-05
R09 N08 N09 7.13e-03
L10 N09 N10 2.51e-11
R10 N09 N10 9.89e-02
L11 N10 N11 1.61e-10
R11 N10 N11 3.48e-02
C12 N11 N12 6.36e-06
L12 N11 N12 3.09e-11
R12 N11 N12 6.95e-03
C13 N12 N13 1.45e-06
L13 N12 N13 6.32e-11
R13 N12 N13 1.33e-02
C14 N13 Port2 8.23e-12
L14 N13 Port2 7.47e-11
R14 N13 Port2 1.27e+01
.ENDS GRM219C81E225KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM219C81E225ME15
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C81E225ME15 Port1 Port2
C01 Port1 N01 1.58e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.76e-10
R03 N02 N03 5.55e-03
C04 N03 N04 7.50e-05
R04 N03 N04 6.37e+01
C05 N04 N05 9.43e-05
R05 N04 N05 7.16e+00
C06 N05 N06 6.36e-05
R06 N05 N06 1.45e+00
C07 N06 N07 6.30e-05
R07 N06 N07 1.80e-01
C08 N07 N08 5.15e-05
R08 N07 N08 3.38e-02
C09 N08 N09 5.38e-05
R09 N08 N09 7.13e-03
L10 N09 N10 2.51e-11
R10 N09 N10 9.89e-02
L11 N10 N11 1.61e-10
R11 N10 N11 3.48e-02
C12 N11 N12 6.36e-06
L12 N11 N12 3.09e-11
R12 N11 N12 6.95e-03
C13 N12 N13 1.45e-06
L13 N12 N13 6.32e-11
R13 N12 N13 1.33e-02
C14 N13 Port2 8.23e-12
L14 N13 Port2 7.47e-11
R14 N13 Port2 1.27e+01
.ENDS GRM219C81E225ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+00[uF]/35[V]
* Murata P/N :GRM219C8YA225KE15
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C8YA225KE15 Port1 Port2
C01 Port1 N01 1.63e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.14e-10
R03 N02 N03 5.44e-03
C04 N03 N04 7.09e-05
R04 N03 N04 4.76e+01
C05 N04 N05 8.58e-05
R05 N04 N05 5.71e+00
C06 N05 N06 7.10e-05
R06 N05 N06 1.11e+00
C07 N06 N07 6.06e-05
R07 N06 N07 1.85e-01
C08 N07 N08 5.61e-05
R08 N07 N08 3.06e-02
C09 N08 N09 4.37e-05
R09 N08 N09 7.72e-03
L10 N09 N10 8.47e-12
R10 N09 N10 3.99e-02
L11 N10 N11 2.18e-11
R11 N10 N11 3.16e-02
L12 N11 N12 1.64e-10
R12 N11 N12 2.77e-02
C13 N12 N13 5.74e-06
L13 N12 N13 3.51e-11
R13 N12 N13 7.29e-03
C14 N13 N14 2.22e-06
L14 N13 N14 4.25e-11
R14 N13 N14 1.12e-02
C15 N14 Port2 8.18e-12
L15 N14 Port2 7.22e-11
R15 N14 Port2 1.12e+01
.ENDS GRM219C8YA225KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+00[uF]/35[V]
* Murata P/N :GRM219C8YA225ME15
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219C8YA225ME15 Port1 Port2
C01 Port1 N01 1.63e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.14e-10
R03 N02 N03 5.44e-03
C04 N03 N04 7.09e-05
R04 N03 N04 4.76e+01
C05 N04 N05 8.58e-05
R05 N04 N05 5.71e+00
C06 N05 N06 7.10e-05
R06 N05 N06 1.11e+00
C07 N06 N07 6.06e-05
R07 N06 N07 1.85e-01
C08 N07 N08 5.61e-05
R08 N07 N08 3.06e-02
C09 N08 N09 4.37e-05
R09 N08 N09 7.72e-03
L10 N09 N10 8.47e-12
R10 N09 N10 3.99e-02
L11 N10 N11 2.18e-11
R11 N10 N11 3.16e-02
L12 N11 N12 1.64e-10
R12 N11 N12 2.77e-02
C13 N12 N13 5.74e-06
L13 N12 N13 3.51e-11
R13 N12 N13 7.29e-03
C14 N13 N14 2.22e-06
L14 N13 N14 4.25e-11
R14 N13 N14 1.12e-02
C15 N14 Port2 8.18e-12
L15 N14 Port2 7.22e-11
R15 N14 Port2 1.12e+01
.ENDS GRM219C8YA225ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM219D71A475KE15
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219D71A475KE15 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219D71A475KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM219D71A475ME15
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219D71A475ME15 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219D71A475ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRM219D71C225KA12
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219D71C225KA12 Port1 Port2
C01 Port1 N01 1.64e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.81e-10
R03 N02 N03 6.58e-03
C04 N03 N04 5.64e-05
R04 N03 N04 7.90e+01
C05 N04 N05 4.76e-05
R05 N04 N05 8.53e+00
C06 N05 N06 5.04e-05
R06 N05 N06 8.60e-01
C07 N06 N07 5.14e-05
R07 N06 N07 1.99e-01
C08 N07 N08 3.59e-05
R08 N07 N08 4.92e-02
C09 N08 N09 2.89e-05
R09 N08 N09 9.26e-03
L10 N09 N10 2.76e-11
R10 N09 N10 1.89e-01
L11 N10 N11 5.92e-11
R11 N10 N11 4.13e-02
L12 N11 N12 3.75e-11
R12 N11 N12 1.30e-02
C13 N12 N13 5.75e-06
L13 N12 N13 3.35e-11
R13 N12 N13 6.93e-03
C14 N13 N14 1.26e-06
L14 N13 N14 7.04e-11
R14 N13 N14 1.41e-02
C15 N14 N15 3.24e-07
L15 N14 N15 4.89e-11
R15 N14 N15 8.20e-03
C16 N15 N16 1.92e-11
L16 N15 N16 3.91e-11
R16 N15 N16 6.39e+00
C17 N16 Port2 6.63e-12
L17 N16 Port2 4.72e-11
R17 N16 Port2 8.00e+00
.ENDS GRM219D71C225KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRM219D71C225MA12
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219D71C225MA12 Port1 Port2
C01 Port1 N01 1.64e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.81e-10
R03 N02 N03 6.58e-03
C04 N03 N04 5.64e-05
R04 N03 N04 7.90e+01
C05 N04 N05 4.76e-05
R05 N04 N05 8.53e+00
C06 N05 N06 5.04e-05
R06 N05 N06 8.60e-01
C07 N06 N07 5.14e-05
R07 N06 N07 1.99e-01
C08 N07 N08 3.59e-05
R08 N07 N08 4.92e-02
C09 N08 N09 2.89e-05
R09 N08 N09 9.26e-03
L10 N09 N10 2.76e-11
R10 N09 N10 1.89e-01
L11 N10 N11 5.92e-11
R11 N10 N11 4.13e-02
L12 N11 N12 3.75e-11
R12 N11 N12 1.30e-02
C13 N12 N13 5.75e-06
L13 N12 N13 3.35e-11
R13 N12 N13 6.93e-03
C14 N13 N14 1.26e-06
L14 N13 N14 7.04e-11
R14 N13 N14 1.41e-02
C15 N14 N15 3.24e-07
L15 N14 N15 4.89e-11
R15 N14 N15 8.20e-03
C16 N15 N16 1.92e-11
L16 N15 N16 3.91e-11
R16 N15 N16 6.39e+00
C17 N16 Port2 6.63e-12
L17 N16 Port2 4.72e-11
R17 N16 Port2 8.00e+00
.ENDS GRM219D71C225MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6T(-55to105[deg])/4.70e+01[uF]/2.5[V]
* Murata P/N :GRM219D80E476ME44
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219D80E476ME44 Port1 Port2
C01 Port1 N01 3.49e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.80e-10
R03 N02 N03 1.85e-03
C04 N03 N04 1.65e-03
R04 N03 N04 3.22e+00
C05 N04 N05 1.87e-03
R05 N04 N05 3.43e-01
C06 N05 N06 2.32e-03
R06 N05 N06 3.15e-02
C07 N06 N07 2.98e-03
R07 N06 N07 1.98e-03
L08 N07 N08 2.08e-11
R08 N07 N08 7.19e-02
L09 N08 N09 7.28e-11
R09 N08 N09 2.55e-02
L10 N09 N10 3.60e-10
R10 N09 N10 9.92e-03
C11 N10 N11 2.64e-05
L11 N10 N11 1.93e-10
R11 N10 N11 2.97e-03
C12 N11 N12 2.15e-11
L12 N11 N12 4.17e-11
R12 N11 N12 3.79e+00
C13 N12 Port2 1.38e-11
L13 N12 Port2 2.43e-11
R13 N12 Port2 3.26e+00
.ENDS GRM219D80E476ME44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/6.80e-01[uF]/16[V]
* Murata P/N :GRM219R11C684KA01
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R11C684KA01 Port1 Port2
C01 Port1 N01 6.59e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.69e-10
R03 N02 N03 5.13e-03
C04 N03 N04 9.28e-05
R04 N03 N04 4.29e+01
C05 N04 N05 1.15e-04
R05 N04 N05 6.64e+00
C06 N05 N06 8.87e-05
R06 N05 N06 8.36e-01
C07 N06 N07 8.11e-05
R07 N06 N07 8.11e-02
C08 N07 N08 5.82e-05
R08 N07 N08 1.20e-02
L09 N08 N09 2.56e-11
R09 N08 N09 9.54e-02
L10 N09 N10 1.78e-10
R10 N09 N10 4.46e-02
C11 N10 N11 2.82e-06
L11 N10 N11 3.61e-11
R11 N10 N11 1.40e-02
C12 N11 N12 8.29e-07
L12 N11 N12 5.41e-11
R12 N11 N12 2.05e-02
C13 N12 N13 1.06e-11
L13 N12 N13 5.91e-11
R13 N12 N13 7.37e+00
C14 N13 Port2 6.91e-12
L14 N13 Port2 4.76e-11
R14 N13 Port2 7.77e+00
.ENDS GRM219R11C684KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GRM219R11E474KA88
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R11E474KA88 Port1 Port2
C01 Port1 N01 4.56e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.78e-10
R03 N02 N03 7.47e-03
C04 N03 N04 6.52e-05
R04 N03 N04 6.75e+01
C05 N04 N05 6.95e-05
R05 N04 N05 1.17e+01
C06 N05 N06 5.83e-05
R06 N05 N06 1.58e+00
C07 N06 N07 5.06e-05
R07 N06 N07 1.80e-01
C08 N07 N08 3.44e-05
R08 N07 N08 2.64e-02
C09 N08 N09 5.42e-05
R09 N08 N09 2.68e-03
L10 N09 N10 1.73e-11
R10 N09 N10 7.49e-02
L11 N10 N11 1.25e-10
R11 N10 N11 4.49e-02
C12 N11 N12 2.25e-06
L12 N11 N12 2.51e-11
R12 N11 N12 1.09e-02
C13 N12 N13 4.42e-07
L13 N12 N13 5.48e-11
R13 N12 N13 2.32e-02
C14 N13 N14 1.21e-11
L14 N13 N14 7.46e-11
R14 N13 N14 8.34e+00
C15 N14 Port2 3.22e-12
L15 N14 Port2 1.07e-10
R15 N14 Port2 2.16e+01
.ENDS GRM219R11E474KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GRM219R11E474MA88
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R11E474MA88 Port1 Port2
C01 Port1 N01 4.56e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.78e-10
R03 N02 N03 7.47e-03
C04 N03 N04 6.52e-05
R04 N03 N04 6.75e+01
C05 N04 N05 6.95e-05
R05 N04 N05 1.17e+01
C06 N05 N06 5.83e-05
R06 N05 N06 1.58e+00
C07 N06 N07 5.06e-05
R07 N06 N07 1.80e-01
C08 N07 N08 3.44e-05
R08 N07 N08 2.64e-02
C09 N08 N09 5.42e-05
R09 N08 N09 2.68e-03
L10 N09 N10 1.73e-11
R10 N09 N10 7.49e-02
L11 N10 N11 1.25e-10
R11 N10 N11 4.49e-02
C12 N11 N12 2.25e-06
L12 N11 N12 2.51e-11
R12 N11 N12 1.09e-02
C13 N12 N13 4.42e-07
L13 N12 N13 5.48e-11
R13 N12 N13 2.32e-02
C14 N13 N14 1.21e-11
L14 N13 N14 7.46e-11
R14 N13 N14 8.34e+00
C15 N14 Port2 3.22e-12
L15 N14 Port2 1.07e-10
R15 N14 Port2 2.16e+01
.ENDS GRM219R11E474MA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/6.80e-02[uF]/25[V]
* Murata P/N :GRM219R11E683KA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R11E683KA01 Port1 Port2
C01 Port1 N01 6.81e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 2.15e-10
R03 N02 N03 1.59e-02
C04 N03 N04 8.44e-06
R04 N03 N04 6.07e+02
C05 N04 N05 1.40e-05
R05 N04 N05 5.93e+01
C06 N05 N06 1.02e-05
R06 N05 N06 1.24e+01
C07 N06 N07 1.09e-05
R07 N06 N07 1.30e+00
C08 N07 N08 1.06e-05
R08 N07 N08 2.80e-01
C09 N08 N09 9.20e-06
R09 N08 N09 6.77e-02
C10 N09 N10 3.94e-06
R10 N09 N10 2.52e-02
L11 N10 N11 1.39e-10
R11 N10 N11 1.06e-01
L12 N11 N12 7.38e-12
R12 N11 N12 6.12e-02
C13 N12 N13 4.44e-07
L13 N12 N13 1.87e-11
R13 N12 N13 3.08e-02
C14 N13 N14 7.58e-08
L14 N13 N14 4.75e-11
R14 N13 N14 5.42e-02
C15 N14 N15 1.35e-11
L15 N14 N15 6.54e-11
R15 N14 N15 6.04e+00
C16 N15 Port2 7.08e-12
L16 N15 Port2 4.50e-11
R16 N15 Port2 4.66e+00
.ENDS GRM219R11E683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GRM219R11H333KA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R11H333KA01 Port1 Port2
C01 Port1 N01 3.32e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 2.31e-02
C04 N03 N04 3.49e-06
R04 N03 N04 9.14e+02
C05 N04 N05 5.71e-06
R05 N04 N05 6.04e+01
C06 N05 N06 5.66e-06
R06 N05 N06 8.33e+00
C07 N06 N07 4.77e-06
R07 N06 N07 1.66e+00
C08 N07 N08 4.32e-06
R08 N07 N08 2.71e-01
C09 N08 N09 2.33e-06
R09 N08 N09 7.85e-02
C10 N09 N10 1.34e-06
R10 N09 N10 1.79e-02
L11 N10 N11 1.14e-10
R11 N10 N11 1.59e-01
C12 N11 N12 1.18e-07
L12 N11 N12 3.01e-11
R12 N11 N12 4.36e-02
C13 N12 N13 3.54e-08
L13 N12 N13 3.96e-11
R13 N12 N13 7.16e-02
C14 N13 N14 1.03e-11
L14 N13 N14 7.97e-11
R14 N13 N14 7.47e+00
C15 N14 Port2 2.15e-12
L15 N14 Port2 1.26e-10
R15 N14 Port2 2.36e+01
.ENDS GRM219R11H333KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/4[V]
* Murata P/N :GRM219R60G226ME66
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R60G226ME66 Port1 Port2
C01 Port1 N01 1.62e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.66e-10
R03 N02 N03 2.06e-03
C04 N03 N04 6.32e-04
R04 N03 N04 7.69e+00
C05 N04 N05 8.11e-04
R05 N04 N05 7.63e-01
C06 N05 N06 1.14e-03
R06 N05 N06 6.07e-02
C07 N06 N07 1.17e-03
R07 N06 N07 4.25e-03
L08 N07 N08 1.54e-11
R08 N07 N08 7.88e-02
L09 N08 N09 6.00e-11
R09 N08 N09 3.09e-02
L10 N09 N10 3.49e-10
R10 N09 N10 1.21e-02
C11 N10 N11 9.34e-05
L11 N10 N11 3.73e-11
R11 N10 N11 1.89e-03
C12 N11 N12 3.07e-05
L12 N11 N12 6.20e-11
R12 N11 N12 3.24e-03
C13 N12 N13 1.60e-11
L13 N12 N13 5.23e-11
R13 N12 N13 6.07e+00
C14 N13 Port2 1.04e-11
L14 N13 Port2 2.94e-11
R14 N13 Port2 9.32e+00
.ENDS GRM219R60G226ME66
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+01[uF]/4[V]
* Murata P/N :GRM219R60G476ME44
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R60G476ME44 Port1 Port2
C01 Port1 N01 3.49e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.80e-10
R03 N02 N03 1.85e-03
C04 N03 N04 1.65e-03
R04 N03 N04 3.22e+00
C05 N04 N05 1.87e-03
R05 N04 N05 3.43e-01
C06 N05 N06 2.32e-03
R06 N05 N06 3.15e-02
C07 N06 N07 2.98e-03
R07 N06 N07 1.98e-03
L08 N07 N08 2.08e-11
R08 N07 N08 7.19e-02
L09 N08 N09 7.28e-11
R09 N08 N09 2.55e-02
L10 N09 N10 3.60e-10
R10 N09 N10 9.92e-03
C11 N10 N11 2.64e-05
L11 N10 N11 1.93e-10
R11 N10 N11 2.97e-03
C12 N11 N12 2.15e-11
L12 N11 N12 4.17e-11
R12 N11 N12 3.79e+00
C13 N12 Port2 1.38e-11
L13 N12 Port2 2.43e-11
R13 N12 Port2 3.26e+00
.ENDS GRM219R60G476ME44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM219R60J106KE19
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R60J106KE19 Port1 Port2
C01 Port1 N01 7.34e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 3.04e-03
C04 N03 N04 1.34e-04
R04 N03 N04 4.05e+01
C05 N04 N05 1.96e-04
R05 N04 N05 2.13e+00
C06 N05 N06 1.90e-04
R06 N05 N06 2.23e-01
C07 N06 N07 1.50e-04
R07 N06 N07 2.84e-02
C08 N07 N08 1.19e-04
R08 N07 N08 3.53e-03
L09 N08 N09 1.21e-11
R09 N08 N09 7.97e-02
L10 N09 N10 3.72e-11
R10 N09 N10 3.54e-02
L11 N10 N11 3.03e-10
R11 N10 N11 1.69e-02
C12 N11 N12 1.83e-05
L12 N11 N12 4.93e-11
R12 N11 N12 3.48e-03
C13 N12 N13 1.78e-05
L13 N12 N13 2.60e-11
R13 N12 N13 3.94e-03
C14 N13 N14 7.85e-12
L14 N13 N14 7.54e-11
R14 N13 N14 9.88e+00
C15 N14 Port2 4.57e-12
L15 N14 Port2 5.82e-11
R15 N14 Port2 2.35e+01
.ENDS GRM219R60J106KE19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM219R60J106ME19
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R60J106ME19 Port1 Port2
C01 Port1 N01 7.34e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 3.04e-03
C04 N03 N04 1.34e-04
R04 N03 N04 4.05e+01
C05 N04 N05 1.96e-04
R05 N04 N05 2.13e+00
C06 N05 N06 1.90e-04
R06 N05 N06 2.23e-01
C07 N06 N07 1.50e-04
R07 N06 N07 2.84e-02
C08 N07 N08 1.19e-04
R08 N07 N08 3.53e-03
L09 N08 N09 1.21e-11
R09 N08 N09 7.97e-02
L10 N09 N10 3.72e-11
R10 N09 N10 3.54e-02
L11 N10 N11 3.03e-10
R11 N10 N11 1.69e-02
C12 N11 N12 1.83e-05
L12 N11 N12 4.93e-11
R12 N11 N12 3.48e-03
C13 N12 N13 1.78e-05
L13 N12 N13 2.60e-11
R13 N12 N13 3.94e-03
C14 N13 N14 7.85e-12
L14 N13 N14 7.54e-11
R14 N13 N14 9.88e+00
C15 N14 Port2 4.57e-12
L15 N14 Port2 5.82e-11
R15 N14 Port2 2.35e+01
.ENDS GRM219R60J106ME19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRM219R60J226ME47
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R60J226ME47 Port1 Port2
C01 Port1 N01 1.59e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.85e-10
R03 N02 N03 2.19e-03
C04 N03 N04 6.81e-04
R04 N03 N04 7.79e+00
C05 N04 N05 7.22e-04
R05 N04 N05 9.22e-01
C06 N05 N06 1.03e-03
R06 N05 N06 6.64e-02
C07 N06 N07 1.11e-03
R07 N06 N07 4.53e-03
L08 N07 N08 1.39e-11
R08 N07 N08 7.42e-02
L09 N08 N09 5.38e-11
R09 N08 N09 3.23e-02
L10 N09 N10 3.02e-10
R10 N09 N10 1.34e-02
C11 N10 N11 1.18e-05
L11 N10 N11 1.68e-10
R11 N10 N11 4.38e-03
C12 N11 N12 2.05e-11
L12 N11 N12 3.86e-11
R12 N11 N12 4.93e+00
C13 N12 Port2 9.10e-12
L13 N12 Port2 3.16e-11
R13 N12 Port2 4.12e+00
.ENDS GRM219R60J226ME47
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRM219R60J226MEA0
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R60J226MEA0 Port1 Port2
C01 Port1 N01 1.62e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.66e-10
R03 N02 N03 2.06e-03
C04 N03 N04 6.32e-04
R04 N03 N04 7.69e+00
C05 N04 N05 8.11e-04
R05 N04 N05 7.63e-01
C06 N05 N06 1.14e-03
R06 N05 N06 6.07e-02
C07 N06 N07 1.17e-03
R07 N06 N07 4.25e-03
L08 N07 N08 1.54e-11
R08 N07 N08 7.88e-02
L09 N08 N09 6.00e-11
R09 N08 N09 3.09e-02
L10 N09 N10 3.49e-10
R10 N09 N10 1.21e-02
C11 N10 N11 9.34e-05
L11 N10 N11 3.73e-11
R11 N10 N11 1.89e-03
C12 N11 N12 3.07e-05
L12 N11 N12 6.20e-11
R12 N11 N12 3.24e-03
C13 N12 N13 1.60e-11
L13 N12 N13 5.23e-11
R13 N12 N13 6.07e+00
C14 N13 Port2 1.04e-11
L14 N13 Port2 2.94e-11
R14 N13 Port2 9.32e+00
.ENDS GRM219R60J226MEA0
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRM219R60J475KE19
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R60J475KE19 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219R60J475KE19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRM219R60J476ME44
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R60J476ME44 Port1 Port2
C01 Port1 N01 3.36e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 2.02e-10
R03 N02 N03 1.97e-03
C04 N03 N04 1.45e-03
R04 N03 N04 2.59e+00
C05 N04 N05 2.07e-03
R05 N04 N05 2.07e-01
C06 N05 N06 2.53e-03
R06 N05 N06 2.15e-02
C07 N06 N07 3.34e-03
R07 N06 N07 1.34e-03
L08 N07 N08 1.73e-11
R08 N07 N08 8.96e-02
L09 N08 N09 2.30e-11
R09 N08 N09 2.32e-02
L10 N09 N10 6.45e-11
R10 N09 N10 1.56e-02
L11 N10 N11 3.57e-10
R11 N10 N11 9.05e-03
C12 N11 N12 1.25e-04
L12 N11 N12 8.49e-11
R12 N11 N12 1.24e-03
C13 N12 N13 5.16e-05
L13 N12 N13 8.73e-11
R13 N12 N13 1.49e-03
C14 N13 Port2 1.54e-11
L14 N13 Port2 5.83e-11
R14 N13 Port2 5.65e+00
.ENDS GRM219R60J476ME44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRM219R61A105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61A105KA01 Port1 Port2
C01 Port1 N01 9.50e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.71e-10
R03 N02 N03 4.90e-03
C04 N03 N04 1.45e-04
R04 N03 N04 5.41e+00
C05 N04 N05 1.14e-04
R05 N04 N05 7.02e-01
C06 N05 N06 1.09e-04
R06 N05 N06 8.51e-02
C07 N06 N07 7.72e-05
R07 N06 N07 1.11e-02
L08 N07 N08 2.52e-11
R08 N07 N08 5.66e-02
L09 N08 N09 1.79e-10
R09 N08 N09 3.76e-02
C10 N09 N10 4.31e-06
L10 N09 N10 3.29e-11
R10 N09 N10 1.09e-02
C11 N10 N11 1.32e-06
L11 N10 N11 5.10e-11
R11 N10 N11 1.68e-02
C12 N11 N12 1.23e-11
L12 N11 N12 6.03e-11
R12 N11 N12 4.97e+00
C13 N12 Port2 7.26e-12
L13 N12 Port2 4.20e-11
R13 N12 Port2 5.26e+00
.ENDS GRM219R61A105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM219R61A106KE44
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61A106KE44 Port1 Port2
C01 Port1 N01 7.36e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.12e-10
R03 N02 N03 3.25e-03
C04 N03 N04 1.33e-04
R04 N03 N04 3.31e+01
C05 N04 N05 1.86e-04
R05 N04 N05 1.95e+00
C06 N05 N06 1.89e-04
R06 N05 N06 1.99e-01
C07 N06 N07 1.42e-04
R07 N06 N07 2.63e-02
C08 N07 N08 1.70e-04
R08 N07 N08 3.12e-03
L09 N08 N09 1.22e-11
R09 N08 N09 7.37e-02
L10 N09 N10 3.75e-11
R10 N09 N10 3.26e-02
L11 N10 N11 2.89e-10
R11 N10 N11 1.81e-02
C12 N11 N12 1.93e-05
L12 N11 N12 5.31e-11
R12 N11 N12 3.97e-03
C13 N12 N13 1.48e-05
L13 N12 N13 3.69e-11
R13 N12 N13 4.73e-03
C14 N13 N14 1.26e-11
L14 N13 N14 5.31e-11
R14 N13 N14 5.57e+00
C15 N14 Port2 6.02e-12
L15 N14 Port2 4.80e-11
R15 N14 Port2 2.30e+01
.ENDS GRM219R61A106KE44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM219R61A106ME44
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61A106ME44 Port1 Port2
C01 Port1 N01 7.36e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.12e-10
R03 N02 N03 3.25e-03
C04 N03 N04 1.33e-04
R04 N03 N04 3.31e+01
C05 N04 N05 1.86e-04
R05 N04 N05 1.95e+00
C06 N05 N06 1.89e-04
R06 N05 N06 1.99e-01
C07 N06 N07 1.42e-04
R07 N06 N07 2.63e-02
C08 N07 N08 1.70e-04
R08 N07 N08 3.12e-03
L09 N08 N09 1.22e-11
R09 N08 N09 7.37e-02
L10 N09 N10 3.75e-11
R10 N09 N10 3.26e-02
L11 N10 N11 2.89e-10
R11 N10 N11 1.81e-02
C12 N11 N12 1.93e-05
L12 N11 N12 5.31e-11
R12 N11 N12 3.97e-03
C13 N12 N13 1.48e-05
L13 N12 N13 3.69e-11
R13 N12 N13 4.73e-03
C14 N13 N14 1.26e-11
L14 N13 N14 5.31e-11
R14 N13 N14 5.57e+00
C15 N14 Port2 6.02e-12
L15 N14 Port2 4.80e-11
R15 N14 Port2 2.30e+01
.ENDS GRM219R61A106ME44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM219R61A106ME47
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61A106ME47 Port1 Port2
C01 Port1 N01 1.05e-05
R01 Port1 N01 5.00e+06
L02 N01 N02 1.42e-10
R03 N02 N03 2.25e-03
C04 N03 N04 1.81e-03
R04 N03 N04 2.78e+00
C05 N04 N05 8.61e-04
R05 N04 N05 1.68e+00
C06 N05 N06 9.34e-04
R06 N05 N06 1.80e-01
C07 N06 N07 1.59e-03
R07 N06 N07 1.12e-02
C08 N07 N08 1.50e-03
R08 N07 N08 2.25e-03
L09 N08 N09 1.91e-11
R09 N08 N09 9.01e-02
L10 N09 N10 4.72e-11
R10 N09 N10 2.85e-02
L11 N10 N11 3.19e-10
R11 N10 N11 1.56e-02
C12 N11 N12 4.47e-05
L12 N11 N12 5.13e-11
R12 N11 N12 2.76e-03
C13 N12 N13 1.42e-05
L13 N12 N13 7.69e-11
R13 N12 N13 4.43e-03
C14 N13 N14 2.41e-11
L14 N13 N14 3.49e-11
R14 N13 N14 3.79e+00
C15 N14 Port2 4.47e-12
L15 N14 Port2 5.24e-11
R15 N14 Port2 1.19e+01
.ENDS GRM219R61A106ME47
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRM219R61A225KA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61A225KA01 Port1 Port2
C01 Port1 N01 1.56e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.45e-10
R03 N02 N03 5.32e-03
C04 N03 N04 4.51e-05
R04 N03 N04 3.80e+01
C05 N04 N05 4.43e-05
R05 N04 N05 3.38e+00
C06 N05 N06 3.58e-05
R06 N05 N06 4.36e-01
C07 N06 N07 2.86e-05
R07 N06 N07 5.07e-02
C08 N07 N08 2.24e-05
R08 N07 N08 6.69e-03
L09 N08 N09 1.56e-11
R09 N08 N09 9.46e-02
L10 N09 N10 2.58e-11
R10 N09 N10 3.77e-02
L11 N10 N11 2.08e-10
R11 N10 N11 3.09e-02
C12 N11 N12 4.77e-06
L12 N11 N12 3.91e-11
R12 N11 N12 8.08e-03
C13 N12 N13 2.43e-06
L13 N12 N13 3.45e-11
R13 N12 N13 9.84e-03
C14 N13 N14 1.23e-11
L14 N13 N14 6.64e-11
R14 N13 N14 7.02e+00
C15 N14 Port2 6.42e-12
L15 N14 Port2 4.85e-11
R15 N14 Port2 9.58e+00
.ENDS GRM219R61A225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRM219R61A226MEA0
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61A226MEA0 Port1 Port2
C01 Port1 N01 1.62e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.66e-10
R03 N02 N03 2.06e-03
C04 N03 N04 6.32e-04
R04 N03 N04 7.69e+00
C05 N04 N05 8.11e-04
R05 N04 N05 7.63e-01
C06 N05 N06 1.14e-03
R06 N05 N06 6.07e-02
C07 N06 N07 1.17e-03
R07 N06 N07 4.25e-03
L08 N07 N08 1.54e-11
R08 N07 N08 7.88e-02
L09 N08 N09 6.00e-11
R09 N08 N09 3.09e-02
L10 N09 N10 3.49e-10
R10 N09 N10 1.21e-02
C11 N10 N11 9.34e-05
L11 N10 N11 3.73e-11
R11 N10 N11 1.89e-03
C12 N11 N12 3.07e-05
L12 N11 N12 6.20e-11
R12 N11 N12 3.24e-03
C13 N12 N13 1.60e-11
L13 N12 N13 5.23e-11
R13 N12 N13 6.07e+00
C14 N13 Port2 1.04e-11
L14 N13 Port2 2.94e-11
R14 N13 Port2 9.32e+00
.ENDS GRM219R61A226MEA0
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/3.30e+00[uF]/10[V]
* Murata P/N :GRM219R61A335KE19
* Property : C = 3.30e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61A335KE19 Port1 Port2
C01 Port1 N01 2.35e-06
R01 Port1 N01 1.52e+07
L02 N01 N02 2.00e-10
R03 N02 N03 4.28e-03
C04 N03 N04 1.15e-04
R04 N03 N04 3.14e+01
C05 N04 N05 1.47e-04
R05 N04 N05 5.44e+00
C06 N05 N06 1.01e-04
R06 N05 N06 1.63e+00
C07 N06 N07 1.07e-04
R07 N06 N07 3.45e-01
C08 N07 N08 9.68e-05
R08 N07 N08 1.11e-01
C09 N08 N09 5.00e-05
R09 N08 N09 3.38e-02
C10 N09 N10 4.13e-05
R10 N09 N10 4.66e-03
L11 N10 N11 8.57e-12
R11 N10 N11 1.00e-01
L12 N11 N12 2.65e-11
R12 N11 N12 3.95e-02
L13 N12 N13 2.03e-10
R13 N12 N13 2.62e-02
C14 N13 N14 1.30e-05
L14 N13 N14 2.30e-11
R14 N13 N14 4.62e-03
C15 N14 N15 2.77e-06
L15 N14 N15 5.13e-11
R15 N14 N15 9.60e-03
C16 N15 Port2 9.46e-12
L16 N15 Port2 7.27e-11
R16 N15 Port2 1.31e+01
.ENDS GRM219R61A335KE19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM219R61A475KE34
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61A475KE34 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219R61A475KE34
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM219R61A475ME34
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61A475ME34 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219R61A475ME34
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM219R61C106KA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61C106KA73 Port1 Port2
C01 Port1 N01 5.83e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.02e-10
R03 N02 N03 3.34e-03
C04 N03 N04 9.36e-05
R04 N03 N04 4.50e+01
C05 N04 N05 1.59e-04
R05 N04 N05 2.39e+00
C06 N05 N06 1.55e-04
R06 N05 N06 2.51e-01
C07 N06 N07 1.21e-04
R07 N06 N07 3.22e-02
C08 N07 N08 1.18e-04
R08 N07 N08 3.32e-03
L09 N08 N09 1.24e-11
R09 N08 N09 8.21e-02
L10 N09 N10 3.68e-11
R10 N09 N10 3.42e-02
L11 N10 N11 2.44e-10
R11 N10 N11 1.82e-02
C12 N11 N12 1.47e-05
L12 N11 N12 5.57e-11
R12 N11 N12 4.17e-03
C13 N12 N13 7.47e-06
L13 N12 N13 6.06e-11
R13 N12 N13 4.89e-03
C14 N13 N14 1.06e-11
L14 N13 N14 6.40e-11
R14 N13 N14 9.84e+00
C15 N14 Port2 2.73e-12
L15 N14 Port2 1.03e-10
R15 N14 Port2 2.71e+01
.ENDS GRM219R61C106KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM219R61C106MA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61C106MA73 Port1 Port2
C01 Port1 N01 5.83e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.02e-10
R03 N02 N03 3.34e-03
C04 N03 N04 9.36e-05
R04 N03 N04 4.50e+01
C05 N04 N05 1.59e-04
R05 N04 N05 2.39e+00
C06 N05 N06 1.55e-04
R06 N05 N06 2.51e-01
C07 N06 N07 1.21e-04
R07 N06 N07 3.22e-02
C08 N07 N08 1.18e-04
R08 N07 N08 3.32e-03
L09 N08 N09 1.24e-11
R09 N08 N09 8.21e-02
L10 N09 N10 3.68e-11
R10 N09 N10 3.42e-02
L11 N10 N11 2.44e-10
R11 N10 N11 1.82e-02
C12 N11 N12 1.47e-05
L12 N11 N12 5.57e-11
R12 N11 N12 4.17e-03
C13 N12 N13 7.47e-06
L13 N12 N13 6.06e-11
R13 N12 N13 4.89e-03
C14 N13 N14 1.06e-11
L14 N13 N14 6.40e-11
R14 N13 N14 9.84e+00
C15 N14 Port2 2.73e-12
L15 N14 Port2 1.03e-10
R15 N14 Port2 2.71e+01
.ENDS GRM219R61C106MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRM219R61C225KA88
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61C225KA88 Port1 Port2
C01 Port1 N01 1.56e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.45e-10
R03 N02 N03 5.32e-03
C04 N03 N04 4.51e-05
R04 N03 N04 3.80e+01
C05 N04 N05 4.43e-05
R05 N04 N05 3.38e+00
C06 N05 N06 3.58e-05
R06 N05 N06 4.36e-01
C07 N06 N07 2.86e-05
R07 N06 N07 5.07e-02
C08 N07 N08 2.24e-05
R08 N07 N08 6.69e-03
L09 N08 N09 1.56e-11
R09 N08 N09 9.46e-02
L10 N09 N10 2.58e-11
R10 N09 N10 3.77e-02
L11 N10 N11 2.08e-10
R11 N10 N11 3.09e-02
C12 N11 N12 4.77e-06
L12 N11 N12 3.91e-11
R12 N11 N12 8.08e-03
C13 N12 N13 2.43e-06
L13 N12 N13 3.45e-11
R13 N12 N13 9.84e-03
C14 N13 N14 1.23e-11
L14 N13 N14 6.64e-11
R14 N13 N14 7.02e+00
C15 N14 Port2 6.42e-12
L15 N14 Port2 4.85e-11
R15 N14 Port2 9.58e+00
.ENDS GRM219R61C225KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GRM219R61C226ME15
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61C226ME15 Port1 Port2
C01 Port1 N01 1.55e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.62e-10
R03 N02 N03 2.54e-03
C04 N03 N04 4.09e-04
R04 N03 N04 3.83e+01
C05 N04 N05 7.02e-04
R05 N04 N05 2.05e+00
C06 N05 N06 7.01e-04
R06 N05 N06 2.94e-01
C07 N06 N07 7.16e-04
R07 N06 N07 4.66e-02
C08 N07 N08 5.99e-04
R08 N07 N08 8.43e-03
C09 N08 N09 7.05e-04
R09 N08 N09 1.41e-03
L10 N09 N10 1.63e-11
R10 N09 N10 6.30e-02
L11 N10 N11 4.64e-11
R11 N10 N11 2.30e-02
L12 N11 N12 2.52e-10
R12 N11 N12 1.27e-02
C13 N12 N13 4.74e-05
L13 N12 N13 6.06e-11
R13 N12 N13 2.46e-03
C14 N13 N14 1.81e-05
L14 N13 N14 8.14e-11
R14 N13 N14 4.19e-03
C15 N14 N15 1.17e-11
L15 N14 N15 6.25e-11
R15 N14 N15 1.13e+01
C16 N15 Port2 1.42e-11
L16 N15 Port2 2.34e-11
R16 N15 Port2 6.39e+00
.ENDS GRM219R61C226ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM219R61C475KE15
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61C475KE15 Port1 Port2
C01 Port1 N01 3.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.59e-11
R03 N02 N03 4.35e-03
C04 N03 N04 5.23e-05
R04 N03 N04 1.01e+02
C05 N04 N05 8.24e-05
R05 N04 N05 4.02e+00
C06 N05 N06 8.12e-05
R06 N05 N06 4.09e-01
C07 N06 N07 6.22e-05
R07 N06 N07 5.31e-02
C08 N07 N08 5.32e-05
R08 N07 N08 6.80e-03
L09 N08 N09 9.47e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.87e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.30e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.25e-05
L12 N11 N12 3.36e-11
R12 N11 N12 4.25e-03
C13 N12 N13 4.16e-06
L13 N12 N13 4.78e-11
R13 N12 N13 7.24e-03
C14 N13 N14 7.64e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.36e+01
C15 N14 Port2 3.09e-12
L15 N14 Port2 9.38e-11
R15 N14 Port2 2.31e+01
.ENDS GRM219R61C475KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM219R61E106KA12
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61E106KA12 Port1 Port2
C01 Port1 N01 6.08e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.65e-10
R03 N02 N03 3.43e-03
C04 N03 N04 1.70e-04
R04 N03 N04 1.99e+01
C05 N04 N05 2.10e-04
R05 N04 N05 1.85e+00
C06 N05 N06 1.96e-04
R06 N05 N06 2.57e-01
C07 N06 N07 1.79e-04
R07 N06 N07 3.29e-02
C08 N07 N08 1.24e-04
R08 N07 N08 5.43e-03
L09 N08 N09 1.61e-11
R09 N08 N09 6.18e-02
L10 N09 N10 3.92e-11
R10 N09 N10 2.49e-02
L11 N10 N11 2.46e-10
R11 N10 N11 1.73e-02
C12 N11 N12 1.90e-05
L12 N11 N12 4.94e-11
R12 N11 N12 3.30e-03
C13 N12 N13 8.65e-06
L13 N12 N13 5.44e-11
R13 N12 N13 5.33e-03
C14 N13 N14 1.41e-11
L14 N13 N14 5.90e-11
R14 N13 N14 7.09e+00
C15 N14 Port2 4.84e-12
L15 N14 Port2 5.30e-11
R15 N14 Port2 1.51e+01
.ENDS GRM219R61E106KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM219R61E106MA12
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61E106MA12 Port1 Port2
C01 Port1 N01 6.08e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.65e-10
R03 N02 N03 3.43e-03
C04 N03 N04 1.70e-04
R04 N03 N04 1.99e+01
C05 N04 N05 2.10e-04
R05 N04 N05 1.85e+00
C06 N05 N06 1.96e-04
R06 N05 N06 2.57e-01
C07 N06 N07 1.79e-04
R07 N06 N07 3.29e-02
C08 N07 N08 1.24e-04
R08 N07 N08 5.43e-03
L09 N08 N09 1.61e-11
R09 N08 N09 6.18e-02
L10 N09 N10 3.92e-11
R10 N09 N10 2.49e-02
L11 N10 N11 2.46e-10
R11 N10 N11 1.73e-02
C12 N11 N12 1.90e-05
L12 N11 N12 4.94e-11
R12 N11 N12 3.30e-03
C13 N12 N13 8.65e-06
L13 N12 N13 5.44e-11
R13 N12 N13 5.33e-03
C14 N13 N14 1.41e-11
L14 N13 N14 5.90e-11
R14 N13 N14 7.09e+00
C15 N14 Port2 4.84e-12
L15 N14 Port2 5.30e-11
R15 N14 Port2 1.51e+01
.ENDS GRM219R61E106MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM219R61E225KA12
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61E225KA12 Port1 Port2
C01 Port1 N01 1.56e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.45e-10
R03 N02 N03 5.32e-03
C04 N03 N04 4.51e-05
R04 N03 N04 3.80e+01
C05 N04 N05 4.43e-05
R05 N04 N05 3.38e+00
C06 N05 N06 3.58e-05
R06 N05 N06 4.36e-01
C07 N06 N07 2.86e-05
R07 N06 N07 5.07e-02
C08 N07 N08 2.24e-05
R08 N07 N08 6.69e-03
L09 N08 N09 1.56e-11
R09 N08 N09 9.46e-02
L10 N09 N10 2.58e-11
R10 N09 N10 3.77e-02
L11 N10 N11 2.08e-10
R11 N10 N11 3.09e-02
C12 N11 N12 4.77e-06
L12 N11 N12 3.91e-11
R12 N11 N12 8.08e-03
C13 N12 N13 2.43e-06
L13 N12 N13 3.45e-11
R13 N12 N13 9.84e-03
C14 N13 N14 1.23e-11
L14 N13 N14 6.64e-11
R14 N13 N14 7.02e+00
C15 N14 Port2 6.42e-12
L15 N14 Port2 4.85e-11
R15 N14 Port2 9.58e+00
.ENDS GRM219R61E225KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM219R61E225MA12
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61E225MA12 Port1 Port2
C01 Port1 N01 1.56e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.45e-10
R03 N02 N03 5.32e-03
C04 N03 N04 4.51e-05
R04 N03 N04 3.80e+01
C05 N04 N05 4.43e-05
R05 N04 N05 3.38e+00
C06 N05 N06 3.58e-05
R06 N05 N06 4.36e-01
C07 N06 N07 2.86e-05
R07 N06 N07 5.07e-02
C08 N07 N08 2.24e-05
R08 N07 N08 6.69e-03
L09 N08 N09 1.56e-11
R09 N08 N09 9.46e-02
L10 N09 N10 2.58e-11
R10 N09 N10 3.77e-02
L11 N10 N11 2.08e-10
R11 N10 N11 3.09e-02
C12 N11 N12 4.77e-06
L12 N11 N12 3.91e-11
R12 N11 N12 8.08e-03
C13 N12 N13 2.43e-06
L13 N12 N13 3.45e-11
R13 N12 N13 9.84e-03
C14 N13 N14 1.23e-11
L14 N13 N14 6.64e-11
R14 N13 N14 7.02e+00
C15 N14 Port2 6.42e-12
L15 N14 Port2 4.85e-11
R15 N14 Port2 9.58e+00
.ENDS GRM219R61E225MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRM219R61E475KA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61E475KA73 Port1 Port2
C01 Port1 N01 3.27e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.92e-10
R03 N02 N03 4.43e-03
C04 N03 N04 1.23e-04
R04 N03 N04 4.01e+01
C05 N04 N05 1.06e-04
R05 N04 N05 5.06e+00
C06 N05 N06 1.09e-04
R06 N05 N06 5.46e-01
C07 N06 N07 9.37e-05
R07 N06 N07 6.93e-02
C08 N07 N08 7.43e-05
R08 N07 N08 1.07e-02
L09 N08 N09 2.04e-11
R09 N08 N09 6.68e-02
L10 N09 N10 1.74e-10
R10 N09 N10 2.31e-02
L11 N10 N11 1.47e-11
R11 N10 N11 8.68e-03
C12 N11 N12 1.98e-05
L12 N11 N12 2.35e-11
R12 N11 N12 3.39e-03
C13 N12 N13 2.62e-06
L13 N12 N13 7.79e-11
R13 N12 N13 9.43e-03
C14 N13 N14 1.44e-11
L14 N13 N14 5.75e-11
R14 N13 N14 9.02e+00
C15 N14 Port2 8.28e-12
L15 N14 Port2 3.82e-11
R15 N14 Port2 1.06e+01
.ENDS GRM219R61E475KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRM219R61E475MA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61E475MA73 Port1 Port2
C01 Port1 N01 3.27e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.92e-10
R03 N02 N03 4.43e-03
C04 N03 N04 1.23e-04
R04 N03 N04 4.01e+01
C05 N04 N05 1.06e-04
R05 N04 N05 5.06e+00
C06 N05 N06 1.09e-04
R06 N05 N06 5.46e-01
C07 N06 N07 9.37e-05
R07 N06 N07 6.93e-02
C08 N07 N08 7.43e-05
R08 N07 N08 1.07e-02
L09 N08 N09 2.04e-11
R09 N08 N09 6.68e-02
L10 N09 N10 1.74e-10
R10 N09 N10 2.31e-02
L11 N10 N11 1.47e-11
R11 N10 N11 8.68e-03
C12 N11 N12 1.98e-05
L12 N11 N12 2.35e-11
R12 N11 N12 3.39e-03
C13 N12 N13 2.62e-06
L13 N12 N13 7.79e-11
R13 N12 N13 9.43e-03
C14 N13 N14 1.44e-11
L14 N13 N14 5.75e-11
R14 N13 N14 9.02e+00
C15 N14 Port2 8.28e-12
L15 N14 Port2 3.82e-11
R15 N14 Port2 1.06e+01
.ENDS GRM219R61E475MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRM219R61H105KA73
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61H105KA73 Port1 Port2
C01 Port1 N01 7.28e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.24e-10
R03 N02 N03 7.68e-03
C04 N03 N04 3.18e-05
R04 N03 N04 1.12e+02
C05 N04 N05 3.69e-05
R05 N04 N05 1.71e+01
C06 N05 N06 2.66e-05
R06 N05 N06 3.90e+00
C07 N06 N07 2.09e-05
R07 N06 N07 6.15e-01
C08 N07 N08 2.47e-05
R08 N07 N08 9.50e-02
C09 N08 N09 2.33e-05
R09 N08 N09 3.25e-02
C10 N09 N10 1.19e-05
R10 N09 N10 1.06e-02
L11 N10 N11 2.80e-11
R11 N10 N11 9.75e-02
L12 N11 N12 1.30e-10
R12 N11 N12 3.40e-02
C13 N12 N13 3.00e-06
L13 N12 N13 2.49e-11
R13 N12 N13 8.54e-03
C14 N13 N14 6.98e-07
L14 N13 N14 4.17e-11
R14 N13 N14 1.48e-02
C15 N14 N15 7.98e-12
L15 N14 N15 9.69e-11
R15 N14 N15 1.69e+01
C16 N15 Port2 3.48e-12
L16 N15 Port2 9.69e-11
R16 N15 Port2 1.91e+01
.ENDS GRM219R61H105KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRM219R61H105MA73
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61H105MA73 Port1 Port2
C01 Port1 N01 7.28e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.24e-10
R03 N02 N03 7.68e-03
C04 N03 N04 3.18e-05
R04 N03 N04 1.12e+02
C05 N04 N05 3.69e-05
R05 N04 N05 1.71e+01
C06 N05 N06 2.66e-05
R06 N05 N06 3.90e+00
C07 N06 N07 2.09e-05
R07 N06 N07 6.15e-01
C08 N07 N08 2.47e-05
R08 N07 N08 9.50e-02
C09 N08 N09 2.33e-05
R09 N08 N09 3.25e-02
C10 N09 N10 1.19e-05
R10 N09 N10 1.06e-02
L11 N10 N11 2.80e-11
R11 N10 N11 9.75e-02
L12 N11 N12 1.30e-10
R12 N11 N12 3.40e-02
C13 N12 N13 3.00e-06
L13 N12 N13 2.49e-11
R13 N12 N13 8.54e-03
C14 N13 N14 6.98e-07
L14 N13 N14 4.17e-11
R14 N13 N14 1.48e-02
C15 N14 N15 7.98e-12
L15 N14 N15 9.69e-11
R15 N14 N15 1.69e+01
C16 N15 Port2 3.48e-12
L16 N15 Port2 9.69e-11
R16 N15 Port2 1.91e+01
.ENDS GRM219R61H105MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRM219R61H225KE15
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61H225KE15 Port1 Port2
C01 Port1 N01 1.63e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.14e-10
R03 N02 N03 5.44e-03
C04 N03 N04 7.09e-05
R04 N03 N04 4.76e+01
C05 N04 N05 8.58e-05
R05 N04 N05 5.71e+00
C06 N05 N06 7.10e-05
R06 N05 N06 1.11e+00
C07 N06 N07 6.06e-05
R07 N06 N07 1.85e-01
C08 N07 N08 5.61e-05
R08 N07 N08 3.06e-02
C09 N08 N09 4.37e-05
R09 N08 N09 7.72e-03
L10 N09 N10 8.47e-12
R10 N09 N10 3.99e-02
L11 N10 N11 2.18e-11
R11 N10 N11 3.16e-02
L12 N11 N12 1.64e-10
R12 N11 N12 2.77e-02
C13 N12 N13 5.74e-06
L13 N12 N13 3.51e-11
R13 N12 N13 7.29e-03
C14 N13 N14 2.22e-06
L14 N13 N14 4.25e-11
R14 N13 N14 1.12e-02
C15 N14 Port2 8.18e-12
L15 N14 Port2 7.22e-11
R15 N14 Port2 1.12e+01
.ENDS GRM219R61H225KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRM219R61H225ME15
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R61H225ME15 Port1 Port2
C01 Port1 N01 1.63e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.14e-10
R03 N02 N03 5.44e-03
C04 N03 N04 7.09e-05
R04 N03 N04 4.76e+01
C05 N04 N05 8.58e-05
R05 N04 N05 5.71e+00
C06 N05 N06 7.10e-05
R06 N05 N06 1.11e+00
C07 N06 N07 6.06e-05
R07 N06 N07 1.85e-01
C08 N07 N08 5.61e-05
R08 N07 N08 3.06e-02
C09 N08 N09 4.37e-05
R09 N08 N09 7.72e-03
L10 N09 N10 8.47e-12
R10 N09 N10 3.99e-02
L11 N10 N11 2.18e-11
R11 N10 N11 3.16e-02
L12 N11 N12 1.64e-10
R12 N11 N12 2.77e-02
C13 N12 N13 5.74e-06
L13 N12 N13 3.51e-11
R13 N12 N13 7.29e-03
C14 N13 N14 2.22e-06
L14 N13 N14 4.25e-11
R14 N13 N14 1.12e-02
C15 N14 Port2 8.18e-12
L15 N14 Port2 7.22e-11
R15 N14 Port2 1.12e+01
.ENDS GRM219R61H225ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GRM219R6YA475KA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R6YA475KA73 Port1 Port2
C01 Port1 N01 3.27e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.92e-10
R03 N02 N03 4.43e-03
C04 N03 N04 1.23e-04
R04 N03 N04 4.01e+01
C05 N04 N05 1.06e-04
R05 N04 N05 5.06e+00
C06 N05 N06 1.09e-04
R06 N05 N06 5.46e-01
C07 N06 N07 9.37e-05
R07 N06 N07 6.93e-02
C08 N07 N08 7.43e-05
R08 N07 N08 1.07e-02
L09 N08 N09 2.04e-11
R09 N08 N09 6.68e-02
L10 N09 N10 1.74e-10
R10 N09 N10 2.31e-02
L11 N10 N11 1.47e-11
R11 N10 N11 8.68e-03
C12 N11 N12 1.98e-05
L12 N11 N12 2.35e-11
R12 N11 N12 3.39e-03
C13 N12 N13 2.62e-06
L13 N12 N13 7.79e-11
R13 N12 N13 9.43e-03
C14 N13 N14 1.44e-11
L14 N13 N14 5.75e-11
R14 N13 N14 9.02e+00
C15 N14 Port2 8.28e-12
L15 N14 Port2 3.82e-11
R15 N14 Port2 1.06e+01
.ENDS GRM219R6YA475KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GRM219R6YA475MA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R6YA475MA73 Port1 Port2
C01 Port1 N01 3.27e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.92e-10
R03 N02 N03 4.43e-03
C04 N03 N04 1.23e-04
R04 N03 N04 4.01e+01
C05 N04 N05 1.06e-04
R05 N04 N05 5.06e+00
C06 N05 N06 1.09e-04
R06 N05 N06 5.46e-01
C07 N06 N07 9.37e-05
R07 N06 N07 6.93e-02
C08 N07 N08 7.43e-05
R08 N07 N08 1.07e-02
L09 N08 N09 2.04e-11
R09 N08 N09 6.68e-02
L10 N09 N10 1.74e-10
R10 N09 N10 2.31e-02
L11 N10 N11 1.47e-11
R11 N10 N11 8.68e-03
C12 N11 N12 1.98e-05
L12 N11 N12 2.35e-11
R12 N11 N12 3.39e-03
C13 N12 N13 2.62e-06
L13 N12 N13 7.79e-11
R13 N12 N13 9.43e-03
C14 N13 N14 1.44e-11
L14 N13 N14 5.75e-11
R14 N13 N14 9.02e+00
C15 N14 Port2 8.28e-12
L15 N14 Port2 3.82e-11
R15 N14 Port2 1.06e+01
.ENDS GRM219R6YA475MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRM219R71A225KE15
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71A225KE15 Port1 Port2
C01 Port1 N01 1.63e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.14e-10
R03 N02 N03 5.44e-03
C04 N03 N04 7.09e-05
R04 N03 N04 4.76e+01
C05 N04 N05 8.58e-05
R05 N04 N05 5.71e+00
C06 N05 N06 7.10e-05
R06 N05 N06 1.11e+00
C07 N06 N07 6.06e-05
R07 N06 N07 1.85e-01
C08 N07 N08 5.61e-05
R08 N07 N08 3.06e-02
C09 N08 N09 4.37e-05
R09 N08 N09 7.72e-03
L10 N09 N10 8.47e-12
R10 N09 N10 3.99e-02
L11 N10 N11 2.18e-11
R11 N10 N11 3.16e-02
L12 N11 N12 1.64e-10
R12 N11 N12 2.77e-02
C13 N12 N13 5.74e-06
L13 N12 N13 3.51e-11
R13 N12 N13 7.29e-03
C14 N13 N14 2.22e-06
L14 N13 N14 4.25e-11
R14 N13 N14 1.12e-02
C15 N14 Port2 8.18e-12
L15 N14 Port2 7.22e-11
R15 N14 Port2 1.12e+01
.ENDS GRM219R71A225KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRM219R71A225ME15
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71A225ME15 Port1 Port2
C01 Port1 N01 1.63e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.14e-10
R03 N02 N03 5.44e-03
C04 N03 N04 7.09e-05
R04 N03 N04 4.76e+01
C05 N04 N05 8.58e-05
R05 N04 N05 5.71e+00
C06 N05 N06 7.10e-05
R06 N05 N06 1.11e+00
C07 N06 N07 6.06e-05
R07 N06 N07 1.85e-01
C08 N07 N08 5.61e-05
R08 N07 N08 3.06e-02
C09 N08 N09 4.37e-05
R09 N08 N09 7.72e-03
L10 N09 N10 8.47e-12
R10 N09 N10 3.99e-02
L11 N10 N11 2.18e-11
R11 N10 N11 3.16e-02
L12 N11 N12 1.64e-10
R12 N11 N12 2.77e-02
C13 N12 N13 5.74e-06
L13 N12 N13 3.51e-11
R13 N12 N13 7.29e-03
C14 N13 N14 2.22e-06
L14 N13 N14 4.25e-11
R14 N13 N14 1.12e-02
C15 N14 Port2 8.18e-12
L15 N14 Port2 7.22e-11
R15 N14 Port2 1.12e+01
.ENDS GRM219R71A225ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRM219R71C225KE15
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71C225KE15 Port1 Port2
C01 Port1 N01 1.58e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.76e-10
R03 N02 N03 5.55e-03
C04 N03 N04 7.50e-05
R04 N03 N04 6.37e+01
C05 N04 N05 9.43e-05
R05 N04 N05 7.16e+00
C06 N05 N06 6.36e-05
R06 N05 N06 1.45e+00
C07 N06 N07 6.30e-05
R07 N06 N07 1.80e-01
C08 N07 N08 5.15e-05
R08 N07 N08 3.38e-02
C09 N08 N09 5.38e-05
R09 N08 N09 7.13e-03
L10 N09 N10 2.51e-11
R10 N09 N10 9.89e-02
L11 N10 N11 1.61e-10
R11 N10 N11 3.48e-02
C12 N11 N12 6.36e-06
L12 N11 N12 3.09e-11
R12 N11 N12 6.95e-03
C13 N12 N13 1.45e-06
L13 N12 N13 6.32e-11
R13 N12 N13 1.33e-02
C14 N13 Port2 8.23e-12
L14 N13 Port2 7.47e-11
R14 N13 Port2 1.27e+01
.ENDS GRM219R71C225KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRM219R71C225ME15
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71C225ME15 Port1 Port2
C01 Port1 N01 1.58e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.76e-10
R03 N02 N03 5.55e-03
C04 N03 N04 7.50e-05
R04 N03 N04 6.37e+01
C05 N04 N05 9.43e-05
R05 N04 N05 7.16e+00
C06 N05 N06 6.36e-05
R06 N05 N06 1.45e+00
C07 N06 N07 6.30e-05
R07 N06 N07 1.80e-01
C08 N07 N08 5.15e-05
R08 N07 N08 3.38e-02
C09 N08 N09 5.38e-05
R09 N08 N09 7.13e-03
L10 N09 N10 2.51e-11
R10 N09 N10 9.89e-02
L11 N10 N11 1.61e-10
R11 N10 N11 3.48e-02
C12 N11 N12 6.36e-06
L12 N11 N12 3.09e-11
R12 N11 N12 6.95e-03
C13 N12 N13 1.45e-06
L13 N12 N13 6.32e-11
R13 N12 N13 1.33e-02
C14 N13 Port2 8.23e-12
L14 N13 Port2 7.47e-11
R14 N13 Port2 1.27e+01
.ENDS GRM219R71C225ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/16[V]
* Murata P/N :GRM219R71C334KA88
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71C334KA88 Port1 Port2
C01 Port1 N01 3.06e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.52e-10
R03 N02 N03 8.62e-03
C04 N03 N04 2.34e-05
R04 N03 N04 9.30e-02
C05 N04 N05 2.25e-05
R05 N04 N05 1.48e-02
L06 N05 N06 1.21e-11
R06 N05 N06 7.25e-02
L07 N06 N07 9.62e-11
R07 N06 N07 6.05e-02
C08 N07 N08 1.35e-06
L08 N07 N08 2.81e-11
R08 N07 N08 1.79e-02
C09 N08 N09 2.18e-07
L09 N08 N09 7.54e-11
R09 N08 N09 3.32e-02
C10 N09 N10 8.22e-12
L10 N09 N10 9.52e-11
R10 N09 N10 1.15e+01
C11 N10 Port2 4.97e-12
L11 N10 Port2 7.35e-11
R11 N10 Port2 1.13e+01
.ENDS GRM219R71C334KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GRM219R71C474KA01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71C474KA01 Port1 Port2
C01 Port1 N01 4.53e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 9.93e-11
R03 N02 N03 6.68e-03
C04 N03 N04 5.83e-05
R04 N03 N04 6.83e+01
C05 N04 N05 8.57e-05
R05 N04 N05 6.67e+00
C06 N05 N06 8.49e-05
R06 N05 N06 9.21e-01
C07 N06 N07 9.94e-05
R07 N06 N07 1.92e-01
C08 N07 N08 5.99e-05
R08 N07 N08 5.68e-02
C09 N08 N09 4.35e-05
R09 N08 N09 8.06e-03
L10 N09 N10 9.02e-12
R10 N09 N10 7.29e-02
L11 N10 N11 1.68e-10
R11 N10 N11 4.80e-02
C12 N11 N12 2.96e-06
L12 N11 N12 1.89e-11
R12 N11 N12 1.16e-02
C13 N12 N13 7.01e-07
L13 N12 N13 3.67e-11
R13 N12 N13 2.20e-02
C14 N13 N14 9.44e-12
L14 N13 N14 1.05e-10
R14 N13 N14 1.27e+01
C15 N14 Port2 2.00e-12
L15 N14 Port2 1.48e-10
R15 N14 Port2 2.42e+01
.ENDS GRM219R71C474KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-01[uF]/16[V]
* Murata P/N :GRM219R71C684KA01
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71C684KA01 Port1 Port2
C01 Port1 N01 6.59e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.69e-10
R03 N02 N03 5.13e-03
C04 N03 N04 9.28e-05
R04 N03 N04 4.29e+01
C05 N04 N05 1.15e-04
R05 N04 N05 6.64e+00
C06 N05 N06 8.87e-05
R06 N05 N06 8.36e-01
C07 N06 N07 8.11e-05
R07 N06 N07 8.11e-02
C08 N07 N08 5.82e-05
R08 N07 N08 1.20e-02
L09 N08 N09 2.56e-11
R09 N08 N09 9.54e-02
L10 N09 N10 1.78e-10
R10 N09 N10 4.46e-02
C11 N10 N11 2.82e-06
L11 N10 N11 3.61e-11
R11 N10 N11 1.40e-02
C12 N11 N12 8.29e-07
L12 N11 N12 5.41e-11
R12 N11 N12 2.05e-02
C13 N12 N13 1.06e-11
L13 N12 N13 5.91e-11
R13 N12 N13 7.37e+00
C14 N13 Port2 6.91e-12
L14 N13 Port2 4.76e-11
R14 N13 Port2 7.77e+00
.ENDS GRM219R71C684KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GRM219R71E104KA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71E104KA01 Port1 Port2
C01 Port1 N01 9.41e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.44e-10
R03 N02 N03 2.08e-02
C04 N03 N04 1.34e-05
R04 N03 N04 2.96e+02
C05 N04 N05 1.76e-05
R05 N04 N05 3.82e+01
C06 N05 N06 1.81e-05
R06 N05 N06 4.28e+00
C07 N06 N07 1.55e-05
R07 N06 N07 9.15e-01
C08 N07 N08 1.48e-05
R08 N07 N08 1.45e-01
C09 N08 N09 1.27e-05
R09 N08 N09 3.10e-02
C10 N09 N10 7.59e-06
R10 N09 N10 1.39e-02
L11 N10 N11 8.28e-11
R11 N10 N11 8.65e-02
L12 N11 N12 3.09e-12
R12 N11 N12 2.27e-02
C13 N12 N13 5.42e-07
L13 N12 N13 1.60e-11
R13 N12 N13 1.05e-02
C14 N13 N14 7.17e-08
L14 N13 N14 4.52e-11
R14 N13 N14 3.23e-02
C15 N14 N15 7.88e-12
L15 N14 N15 1.65e-10
R15 N14 N15 1.49e+01
C16 N15 Port2 2.70e-12
L16 N15 Port2 1.59e-10
R16 N15 Port2 2.27e+01
.ENDS GRM219R71E104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GRM219R71E104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71E104MA01 Port1 Port2
C01 Port1 N01 9.41e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.44e-10
R03 N02 N03 2.08e-02
C04 N03 N04 1.34e-05
R04 N03 N04 2.96e+02
C05 N04 N05 1.76e-05
R05 N04 N05 3.82e+01
C06 N05 N06 1.81e-05
R06 N05 N06 4.28e+00
C07 N06 N07 1.55e-05
R07 N06 N07 9.15e-01
C08 N07 N08 1.48e-05
R08 N07 N08 1.45e-01
C09 N08 N09 1.27e-05
R09 N08 N09 3.10e-02
C10 N09 N10 7.59e-06
R10 N09 N10 1.39e-02
L11 N10 N11 8.28e-11
R11 N10 N11 8.65e-02
L12 N11 N12 3.09e-12
R12 N11 N12 2.27e-02
C13 N12 N13 5.42e-07
L13 N12 N13 1.60e-11
R13 N12 N13 1.05e-02
C14 N13 N14 7.17e-08
L14 N13 N14 4.52e-11
R14 N13 N14 3.23e-02
C15 N14 N15 7.88e-12
L15 N14 N15 1.65e-10
R15 N14 N15 1.49e+01
C16 N15 Port2 2.70e-12
L16 N15 Port2 1.59e-10
R16 N15 Port2 2.27e+01
.ENDS GRM219R71E104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRM219R71E105KA88
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71E105KA88 Port1 Port2
C01 Port1 N01 9.74e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.03e-10
R03 N02 N03 5.32e-03
C04 N03 N04 1.24e-05
R04 N03 N04 5.39e+02
C05 N04 N05 8.65e-05
R05 N04 N05 3.04e+00
C06 N05 N06 8.32e-05
R06 N05 N06 2.81e-01
C07 N06 N07 7.06e-05
R07 N06 N07 3.30e-02
C08 N07 N08 6.08e-05
R08 N07 N08 4.82e-03
L09 N08 N09 1.92e-11
R09 N08 N09 6.28e-02
L10 N09 N10 1.82e-10
R10 N09 N10 3.83e-02
C11 N10 N11 3.68e-06
L11 N10 N11 3.66e-11
R11 N10 N11 1.05e-02
C12 N11 N12 1.03e-06
L12 N11 N12 5.72e-11
R12 N11 N12 1.51e-02
C13 N12 N13 9.24e-12
L13 N12 N13 7.76e-11
R13 N12 N13 8.85e+00
C14 N13 Port2 2.46e-12
L14 N13 Port2 1.20e-10
R14 N13 Port2 2.43e+01
.ENDS GRM219R71E105KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRM219R71E224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71E224MA01 Port1 Port2
C01 Port1 N01 2.15e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.51e-10
R03 N02 N03 8.53e-03
C04 N03 N04 2.31e-05
R04 N03 N04 1.72e+02
C05 N04 N05 4.02e-05
R05 N04 N05 1.34e+01
C06 N05 N06 3.27e-05
R06 N05 N06 2.22e+00
C07 N06 N07 2.92e-05
R07 N06 N07 3.29e-01
C08 N07 N08 3.35e-05
R08 N07 N08 4.33e-02
C09 N08 N09 1.95e-05
R09 N08 N09 1.43e-02
L10 N09 N10 1.43e-10
R10 N09 N10 6.19e-02
L11 N10 N11 6.19e-12
R11 N10 N11 3.00e-02
C12 N11 N12 1.14e-06
L12 N11 N12 2.45e-11
R12 N11 N12 1.91e-02
C13 N12 N13 3.04e-07
L13 N12 N13 4.20e-11
R13 N12 N13 3.79e-02
C14 N13 N14 1.09e-11
L14 N13 N14 9.44e-11
R14 N13 N14 9.69e+00
C15 N14 Port2 2.41e-12
L15 N14 Port2 1.22e-10
R15 N14 Port2 2.96e+01
.ENDS GRM219R71E224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GRM219R71E474KA88
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71E474KA88 Port1 Port2
C01 Port1 N01 4.56e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.78e-10
R03 N02 N03 7.47e-03
C04 N03 N04 6.52e-05
R04 N03 N04 6.75e+01
C05 N04 N05 6.95e-05
R05 N04 N05 1.17e+01
C06 N05 N06 5.83e-05
R06 N05 N06 1.58e+00
C07 N06 N07 5.06e-05
R07 N06 N07 1.80e-01
C08 N07 N08 3.44e-05
R08 N07 N08 2.64e-02
C09 N08 N09 5.42e-05
R09 N08 N09 2.68e-03
L10 N09 N10 1.73e-11
R10 N09 N10 7.49e-02
L11 N10 N11 1.25e-10
R11 N10 N11 4.49e-02
C12 N11 N12 2.25e-06
L12 N11 N12 2.51e-11
R12 N11 N12 1.09e-02
C13 N12 N13 4.42e-07
L13 N12 N13 5.48e-11
R13 N12 N13 2.32e-02
C14 N13 N14 1.21e-11
L14 N13 N14 7.46e-11
R14 N13 N14 8.34e+00
C15 N14 Port2 3.22e-12
L15 N14 Port2 1.07e-10
R15 N14 Port2 2.16e+01
.ENDS GRM219R71E474KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GRM219R71E474MA88
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71E474MA88 Port1 Port2
C01 Port1 N01 4.56e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.78e-10
R03 N02 N03 7.47e-03
C04 N03 N04 6.52e-05
R04 N03 N04 6.75e+01
C05 N04 N05 6.95e-05
R05 N04 N05 1.17e+01
C06 N05 N06 5.83e-05
R06 N05 N06 1.58e+00
C07 N06 N07 5.06e-05
R07 N06 N07 1.80e-01
C08 N07 N08 3.44e-05
R08 N07 N08 2.64e-02
C09 N08 N09 5.42e-05
R09 N08 N09 2.68e-03
L10 N09 N10 1.73e-11
R10 N09 N10 7.49e-02
L11 N10 N11 1.25e-10
R11 N10 N11 4.49e-02
C12 N11 N12 2.25e-06
L12 N11 N12 2.51e-11
R12 N11 N12 1.09e-02
C13 N12 N13 4.42e-07
L13 N12 N13 5.48e-11
R13 N12 N13 2.32e-02
C14 N13 N14 1.21e-11
L14 N13 N14 7.46e-11
R14 N13 N14 8.34e+00
C15 N14 Port2 3.22e-12
L15 N14 Port2 1.07e-10
R15 N14 Port2 2.16e+01
.ENDS GRM219R71E474MA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/25[V]
* Murata P/N :GRM219R71E683KA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71E683KA01 Port1 Port2
C01 Port1 N01 6.81e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 2.15e-10
R03 N02 N03 1.59e-02
C04 N03 N04 8.44e-06
R04 N03 N04 6.07e+02
C05 N04 N05 1.40e-05
R05 N04 N05 5.93e+01
C06 N05 N06 1.02e-05
R06 N05 N06 1.24e+01
C07 N06 N07 1.09e-05
R07 N06 N07 1.30e+00
C08 N07 N08 1.06e-05
R08 N07 N08 2.80e-01
C09 N08 N09 9.20e-06
R09 N08 N09 6.77e-02
C10 N09 N10 3.94e-06
R10 N09 N10 2.52e-02
L11 N10 N11 1.39e-10
R11 N10 N11 1.06e-01
L12 N11 N12 7.38e-12
R12 N11 N12 6.12e-02
C13 N12 N13 4.44e-07
L13 N12 N13 1.87e-11
R13 N12 N13 3.08e-02
C14 N13 N14 7.58e-08
L14 N13 N14 4.75e-11
R14 N13 N14 5.42e-02
C15 N14 N15 1.35e-11
L15 N14 N15 6.54e-11
R15 N14 N15 6.04e+00
C16 N15 Port2 7.08e-12
L16 N15 Port2 4.50e-11
R16 N15 Port2 4.66e+00
.ENDS GRM219R71E683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-01[uF]/25[V]
* Murata P/N :GRM219R71E684KA88
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71E684KA88 Port1 Port2
C01 Port1 N01 6.15e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.64e-10
R03 N02 N03 6.73e-03
C04 N03 N04 7.44e-05
R04 N03 N04 5.34e+01
C05 N04 N05 1.24e-04
R05 N04 N05 6.28e+00
C06 N05 N06 8.68e-05
R06 N05 N06 1.41e+00
C07 N06 N07 8.78e-05
R07 N06 N07 2.18e-01
C08 N07 N08 6.26e-05
R08 N07 N08 2.86e-02
C09 N08 N09 6.01e-05
R09 N08 N09 5.79e-03
L10 N09 N10 1.48e-10
R10 N09 N10 4.35e-02
L11 N10 N11 9.95e-12
R11 N10 N11 3.23e-02
C12 N11 N12 3.26e-06
L12 N11 N12 2.47e-11
R12 N11 N12 9.33e-03
C13 N12 N13 6.47e-07
L13 N12 N13 5.28e-11
R13 N12 N13 1.75e-02
C14 N13 N14 1.30e-11
L14 N13 N14 6.67e-11
R14 N13 N14 8.02e+00
C15 N14 Port2 2.55e-12
L15 N14 Port2 1.43e-10
R15 N14 Port2 1.67e+01
.ENDS GRM219R71E684KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRM219R71H103KA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71H103KA01 Port1 Port2
C01 Port1 N01 1.02e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 5.76e-02
C04 N03 N04 1.45e-06
R04 N03 N04 2.55e+03
C05 N04 N05 2.74e-06
R05 N04 N05 2.99e+02
C06 N05 N06 1.61e-06
R06 N05 N06 8.84e+01
C07 N06 N07 1.61e-06
R07 N06 N07 1.09e+01
C08 N07 N08 1.50e-06
R08 N07 N08 2.03e+00
C09 N08 N09 8.63e-07
R09 N08 N09 4.56e-01
C10 N09 N10 3.65e-07
R10 N09 N10 8.12e-02
L11 N10 N11 1.42e-11
R11 N10 N11 4.07e-01
L12 N11 N12 6.81e-11
R12 N11 N12 1.35e-01
C13 N12 N13 2.65e-07
L13 N12 N13 5.39e-12
R13 N12 N13 1.84e-02
C14 N13 N14 1.89e-08
L14 N13 N14 1.69e-11
R14 N13 N14 5.21e-02
C15 N14 N15 8.18e-12
L15 N14 N15 1.80e-10
R15 N14 N15 1.64e+01
C16 N15 Port2 2.66e-12
L16 N15 Port2 1.85e-10
R16 N15 Port2 1.62e+01
.ENDS GRM219R71H103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GRM219R71H103MA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71H103MA01 Port1 Port2
C01 Port1 N01 1.02e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 5.76e-02
C04 N03 N04 1.45e-06
R04 N03 N04 2.55e+03
C05 N04 N05 2.74e-06
R05 N04 N05 2.99e+02
C06 N05 N06 1.61e-06
R06 N05 N06 8.84e+01
C07 N06 N07 1.61e-06
R07 N06 N07 1.09e+01
C08 N07 N08 1.50e-06
R08 N07 N08 2.03e+00
C09 N08 N09 8.63e-07
R09 N08 N09 4.56e-01
C10 N09 N10 3.65e-07
R10 N09 N10 8.12e-02
L11 N10 N11 1.42e-11
R11 N10 N11 4.07e-01
L12 N11 N12 6.81e-11
R12 N11 N12 1.35e-01
C13 N12 N13 2.65e-07
L13 N12 N13 5.39e-12
R13 N12 N13 1.84e-02
C14 N13 N14 1.89e-08
L14 N13 N14 1.69e-11
R14 N13 N14 5.21e-02
C15 N14 N15 8.18e-12
L15 N14 N15 1.80e-10
R15 N14 N15 1.64e+01
C16 N15 Port2 2.66e-12
L16 N15 Port2 1.85e-10
R16 N15 Port2 1.62e+01
.ENDS GRM219R71H103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GRM219R71H153KA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71H153KA01 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 4.53e-02
C04 N03 N04 1.90e-06
R04 N03 N04 2.24e+03
C05 N04 N05 3.94e-06
R05 N04 N05 2.29e+02
C06 N05 N06 2.33e-06
R06 N05 N06 8.52e+01
C07 N06 N07 2.35e-06
R07 N06 N07 1.05e+01
C08 N07 N08 1.75e-06
R08 N07 N08 2.01e+00
C09 N08 N09 1.82e-06
R09 N08 N09 2.49e-01
C10 N09 N10 1.52e-06
R10 N09 N10 9.74e-02
C11 N10 N11 6.08e-07
R11 N10 N11 3.64e-02
L12 N11 N12 9.79e-11
R12 N11 N12 1.64e-01
C13 N12 N13 1.98e-07
L13 N12 N13 1.01e-11
R13 N12 N13 2.29e-02
C14 N13 N14 1.64e-08
L14 N13 N14 4.98e-11
R14 N13 N14 1.02e-01
C15 N14 N15 1.12e-11
L15 N14 N15 1.70e-10
R15 N14 N15 1.44e+01
C16 N15 Port2 2.30e-12
L16 N15 Port2 2.10e-10
R16 N15 Port2 1.65e+01
.ENDS GRM219R71H153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GRM219R71H153MA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71H153MA01 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 4.53e-02
C04 N03 N04 1.90e-06
R04 N03 N04 2.24e+03
C05 N04 N05 3.94e-06
R05 N04 N05 2.29e+02
C06 N05 N06 2.33e-06
R06 N05 N06 8.52e+01
C07 N06 N07 2.35e-06
R07 N06 N07 1.05e+01
C08 N07 N08 1.75e-06
R08 N07 N08 2.01e+00
C09 N08 N09 1.82e-06
R09 N08 N09 2.49e-01
C10 N09 N10 1.52e-06
R10 N09 N10 9.74e-02
C11 N10 N11 6.08e-07
R11 N10 N11 3.64e-02
L12 N11 N12 9.79e-11
R12 N11 N12 1.64e-01
C13 N12 N13 1.98e-07
L13 N12 N13 1.01e-11
R13 N12 N13 2.29e-02
C14 N13 N14 1.64e-08
L14 N13 N14 4.98e-11
R14 N13 N14 1.02e-01
C15 N14 N15 1.12e-11
L15 N14 N15 1.70e-10
R15 N14 N15 1.44e+01
C16 N15 Port2 2.30e-12
L16 N15 Port2 2.10e-10
R16 N15 Port2 1.65e+01
.ENDS GRM219R71H153MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRM219R71H223KA17
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71H223KA17 Port1 Port2
C01 Port1 N01 2.23e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 3.28e-02
C04 N03 N04 3.03e-06
R04 N03 N04 1.22e+03
C05 N04 N05 7.85e-06
R05 N04 N05 9.92e+01
C06 N05 N06 3.54e-06
R06 N05 N06 3.60e+01
C07 N06 N07 3.40e-06
R07 N06 N07 3.95e+00
C08 N07 N08 2.47e-06
R08 N07 N08 6.19e-01
C09 N08 N09 2.60e-06
R09 N08 N09 7.54e-02
C10 N09 N10 1.26e-06
R10 N09 N10 3.37e-02
L11 N10 N11 8.55e-11
R11 N10 N11 1.53e-01
C12 N11 N12 1.70e-07
L12 N11 N12 1.36e-11
R12 N11 N12 3.10e-02
C13 N12 N13 1.98e-08
L13 N12 N13 4.51e-11
R13 N12 N13 8.65e-02
C14 N13 N14 1.05e-11
L14 N13 N14 1.27e-10
R14 N13 N14 1.16e+01
C15 N14 Port2 2.59e-12
L15 N14 Port2 1.48e-10
R15 N14 Port2 1.79e+01
.ENDS GRM219R71H223KA17
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRM219R71H223MA17
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71H223MA17 Port1 Port2
C01 Port1 N01 2.23e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 3.28e-02
C04 N03 N04 3.03e-06
R04 N03 N04 1.22e+03
C05 N04 N05 7.85e-06
R05 N04 N05 9.92e+01
C06 N05 N06 3.54e-06
R06 N05 N06 3.60e+01
C07 N06 N07 3.40e-06
R07 N06 N07 3.95e+00
C08 N07 N08 2.47e-06
R08 N07 N08 6.19e-01
C09 N08 N09 2.60e-06
R09 N08 N09 7.54e-02
C10 N09 N10 1.26e-06
R10 N09 N10 3.37e-02
L11 N10 N11 8.55e-11
R11 N10 N11 1.53e-01
C12 N11 N12 1.70e-07
L12 N11 N12 1.36e-11
R12 N11 N12 3.10e-02
C13 N12 N13 1.98e-08
L13 N12 N13 4.51e-11
R13 N12 N13 8.65e-02
C14 N13 N14 1.05e-11
L14 N13 N14 1.27e-10
R14 N13 N14 1.16e+01
C15 N14 Port2 2.59e-12
L15 N14 Port2 1.48e-10
R15 N14 Port2 1.79e+01
.ENDS GRM219R71H223MA17
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GRM219R71H333KA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71H333KA01 Port1 Port2
C01 Port1 N01 3.32e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 2.31e-02
C04 N03 N04 3.49e-06
R04 N03 N04 9.14e+02
C05 N04 N05 5.71e-06
R05 N04 N05 6.04e+01
C06 N05 N06 5.66e-06
R06 N05 N06 8.33e+00
C07 N06 N07 4.77e-06
R07 N06 N07 1.66e+00
C08 N07 N08 4.32e-06
R08 N07 N08 2.71e-01
C09 N08 N09 2.33e-06
R09 N08 N09 7.85e-02
C10 N09 N10 1.34e-06
R10 N09 N10 1.79e-02
L11 N10 N11 1.14e-10
R11 N10 N11 1.59e-01
C12 N11 N12 1.18e-07
L12 N11 N12 3.01e-11
R12 N11 N12 4.36e-02
C13 N12 N13 3.54e-08
L13 N12 N13 3.96e-11
R13 N12 N13 7.16e-02
C14 N13 N14 1.03e-11
L14 N13 N14 7.97e-11
R14 N13 N14 7.47e+00
C15 N14 Port2 2.15e-12
L15 N14 Port2 1.26e-10
R15 N14 Port2 2.36e+01
.ENDS GRM219R71H333KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/50[V]
* Murata P/N :GRM219R71H334KA88
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R71H334KA88 Port1 Port2
C01 Port1 N01 3.06e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.52e-10
R03 N02 N03 8.62e-03
C04 N03 N04 2.34e-05
R04 N03 N04 9.30e-02
C05 N04 N05 2.25e-05
R05 N04 N05 1.48e-02
L06 N05 N06 1.21e-11
R06 N05 N06 7.25e-02
L07 N06 N07 9.62e-11
R07 N06 N07 6.05e-02
C08 N07 N08 1.35e-06
L08 N07 N08 2.81e-11
R08 N07 N08 1.79e-02
C09 N08 N09 2.18e-07
L09 N08 N09 7.54e-11
R09 N08 N09 3.32e-02
C10 N09 N10 8.22e-12
L10 N09 N10 9.52e-11
R10 N09 N10 1.15e+01
C11 N10 Port2 4.97e-12
L11 N10 Port2 7.35e-11
R11 N10 Port2 1.13e+01
.ENDS GRM219R71H334KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRM219R72A103KA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R72A103KA01 Port1 Port2
C01 Port1 N01 1.07e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 6.24e-02
C04 N03 N04 1.21e-06
R04 N03 N04 3.04e+03
C05 N04 N05 2.39e-06
R05 N04 N05 2.42e+02
C06 N05 N06 1.80e-06
R06 N05 N06 6.36e+01
C07 N06 N07 1.43e-06
R07 N06 N07 8.95e+00
C08 N07 N08 1.16e-06
R08 N07 N08 1.17e+00
C09 N08 N09 7.08e-07
R09 N08 N09 2.11e-01
C10 N09 N10 4.46e-07
R10 N09 N10 3.47e-02
L11 N10 N11 3.66e-11
R11 N10 N11 2.28e-01
C12 N11 N12 4.69e-09
L12 N11 N12 6.32e-11
R12 N11 N12 1.46e-01
C13 N12 N13 2.46e-11
L13 N12 N13 3.11e-10
R13 N12 N13 4.19e+00
C14 N13 N14 4.26e-12
L14 N13 N14 1.79e-10
R14 N13 N14 1.60e+01
C15 N14 Port2 1.25e-11
L15 N14 Port2 3.67e-11
R15 N14 Port2 8.28e+00
.ENDS GRM219R72A103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRM219R72A103MA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R72A103MA01 Port1 Port2
C01 Port1 N01 1.07e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 6.24e-02
C04 N03 N04 1.21e-06
R04 N03 N04 3.04e+03
C05 N04 N05 2.39e-06
R05 N04 N05 2.42e+02
C06 N05 N06 1.80e-06
R06 N05 N06 6.36e+01
C07 N06 N07 1.43e-06
R07 N06 N07 8.95e+00
C08 N07 N08 1.16e-06
R08 N07 N08 1.17e+00
C09 N08 N09 7.08e-07
R09 N08 N09 2.11e-01
C10 N09 N10 4.46e-07
R10 N09 N10 3.47e-02
L11 N10 N11 3.66e-11
R11 N10 N11 2.28e-01
C12 N11 N12 4.69e-09
L12 N11 N12 6.32e-11
R12 N11 N12 1.46e-01
C13 N12 N13 2.46e-11
L13 N12 N13 3.11e-10
R13 N12 N13 4.19e+00
C14 N13 N14 4.26e-12
L14 N13 N14 1.79e-10
R14 N13 N14 1.60e+01
C15 N14 Port2 1.25e-11
L15 N14 Port2 3.67e-11
R15 N14 Port2 8.28e+00
.ENDS GRM219R72A103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GRM219R72A682KA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R72A682KA01 Port1 Port2
C01 Port1 N01 6.93e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.44e-10
R03 N02 N03 7.15e-02
C04 N03 N04 7.55e-07
R04 N03 N04 2.70e+03
C05 N04 N05 9.87e-07
R05 N04 N05 1.79e+02
C06 N05 N06 9.40e-07
R06 N05 N06 2.10e+01
C07 N06 N07 6.67e-07
R07 N06 N07 2.85e+00
C08 N07 N08 4.24e-07
R08 N07 N08 4.38e-01
C09 N08 N09 2.44e-07
R09 N08 N09 9.05e-02
L10 N09 N10 6.84e-11
R10 N09 N10 2.42e-01
C11 N10 N11 2.68e-08
L11 N10 N11 2.27e-11
R11 N10 N11 7.68e-02
C12 N11 N12 6.19e-09
L12 N11 N12 3.97e-11
R12 N11 N12 1.34e-01
C13 N12 N13 1.22e-11
L13 N12 N13 7.86e-11
R13 N12 N13 1.04e+01
C14 N13 Port2 3.09e-12
L14 N13 Port2 1.31e-10
R14 N13 Port2 1.92e+01
.ENDS GRM219R72A682KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GRM219R7YA105KA12
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R7YA105KA12 Port1 Port2
C01 Port1 N01 9.48e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.83e-10
R03 N02 N03 5.36e-03
C04 N03 N04 1.30e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.10e-04
R05 N04 N05 1.25e+00
C06 N05 N06 9.08e-05
R06 N05 N06 1.74e-01
C07 N06 N07 7.70e-05
R07 N06 N07 2.35e-02
C08 N07 N08 1.07e-04
R08 N07 N08 3.41e-03
L09 N08 N09 1.83e-11
R09 N08 N09 7.06e-02
L10 N09 N10 1.83e-10
R10 N09 N10 4.20e-02
C11 N10 N11 3.95e-06
L11 N10 N11 3.62e-11
R11 N10 N11 1.07e-02
C12 N11 N12 1.04e-06
L12 N11 N12 6.33e-11
R12 N11 N12 1.81e-02
C13 N12 N13 1.46e-11
L13 N12 N13 4.27e-11
R13 N12 N13 6.55e+00
C14 N13 Port2 5.92e-12
L14 N13 Port2 5.78e-11
R14 N13 Port2 8.30e+00
.ENDS GRM219R7YA105KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GRM219R7YA105MA12
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM219R7YA105MA12 Port1 Port2
C01 Port1 N01 9.48e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.83e-10
R03 N02 N03 5.36e-03
C04 N03 N04 1.30e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.10e-04
R05 N04 N05 1.25e+00
C06 N05 N06 9.08e-05
R06 N05 N06 1.74e-01
C07 N06 N07 7.70e-05
R07 N06 N07 2.35e-02
C08 N07 N08 1.07e-04
R08 N07 N08 3.41e-03
L09 N08 N09 1.83e-11
R09 N08 N09 7.06e-02
L10 N09 N10 1.83e-10
R10 N09 N10 4.20e-02
C11 N10 N11 3.95e-06
L11 N10 N11 3.62e-11
R11 N10 N11 1.07e-02
C12 N11 N12 1.04e-06
L12 N11 N12 6.33e-11
R12 N11 N12 1.81e-02
C13 N12 N13 1.46e-11
L13 N12 N13 4.27e-11
R13 N12 N13 6.55e+00
C14 N13 Port2 5.92e-12
L14 N13 Port2 5.78e-11
R14 N13 Port2 8.30e+00
.ENDS GRM219R7YA105MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/100[V]
* Murata P/N :GRM21AR72A224KAC5
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72A224KAC5 Port1 Port2
C01 Port1 N01 2.14e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.45e-10
R03 N02 N03 9.50e-03
C04 N03 N04 3.57e-05
R04 N03 N04 1.50e+02
C05 N04 N05 3.99e-05
R05 N04 N05 2.49e+01
C06 N05 N06 3.15e-05
R06 N05 N06 2.93e+00
C07 N06 N07 2.89e-05
R07 N06 N07 2.79e-01
C08 N07 N08 3.68e-05
R08 N07 N08 4.32e-02
C09 N08 N09 1.96e-05
R09 N08 N09 1.16e-02
L10 N09 N10 1.09e-10
R10 N09 N10 6.37e-02
L11 N10 N11 7.62e-12
R11 N10 N11 4.10e-02
C12 N11 N12 1.05e-06
L12 N11 N12 2.35e-11
R12 N11 N12 1.76e-02
C13 N12 N13 2.51e-07
L13 N12 N13 3.33e-11
R13 N12 N13 2.32e-02
C14 N13 N14 1.54e-11
L14 N13 N14 9.09e-11
R14 N13 N14 6.71e+00
C15 N14 Port2 2.72e-12
L15 N14 Port2 8.63e-11
R15 N14 Port2 1.95e+01
.ENDS GRM21AR72A224KAC5
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/100[V]
* Murata P/N :GRM21AR72A224MAC5
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72A224MAC5 Port1 Port2
C01 Port1 N01 2.14e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.45e-10
R03 N02 N03 9.50e-03
C04 N03 N04 3.57e-05
R04 N03 N04 1.50e+02
C05 N04 N05 3.99e-05
R05 N04 N05 2.49e+01
C06 N05 N06 3.15e-05
R06 N05 N06 2.93e+00
C07 N06 N07 2.89e-05
R07 N06 N07 2.79e-01
C08 N07 N08 3.68e-05
R08 N07 N08 4.32e-02
C09 N08 N09 1.96e-05
R09 N08 N09 1.16e-02
L10 N09 N10 1.09e-10
R10 N09 N10 6.37e-02
L11 N10 N11 7.62e-12
R11 N10 N11 4.10e-02
C12 N11 N12 1.05e-06
L12 N11 N12 2.35e-11
R12 N11 N12 1.76e-02
C13 N12 N13 2.51e-07
L13 N12 N13 3.33e-11
R13 N12 N13 2.32e-02
C14 N13 N14 1.54e-11
L14 N13 N14 9.09e-11
R14 N13 N14 6.71e+00
C15 N14 Port2 2.72e-12
L15 N14 Port2 8.63e-11
R15 N14 Port2 1.95e+01
.ENDS GRM21AR72A224MAC5
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/100[V]
* Murata P/N :GRM21AR72A334KAC5
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72A334KAC5 Port1 Port2
C01 Port1 N01 3.20e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.77e-10
R03 N02 N03 6.78e-03
C04 N03 N04 4.40e-05
R04 N03 N04 9.05e+01
C05 N04 N05 7.12e-05
R05 N04 N05 8.85e+00
C06 N05 N06 5.77e-05
R06 N05 N06 1.37e+00
C07 N06 N07 1.32e-04
R07 N06 N07 1.81e-01
C08 N07 N08 4.67e-05
R08 N07 N08 9.53e-02
C09 N08 N09 2.60e-05
R09 N08 N09 1.67e-02
L10 N09 N10 1.64e-11
R10 N09 N10 7.45e-02
L11 N10 N11 1.65e-10
R11 N10 N11 5.71e-02
C12 N11 N12 1.27e-06
L12 N11 N12 3.17e-11
R12 N11 N12 2.13e-02
C13 N12 N13 4.40e-07
L13 N12 N13 4.08e-11
R13 N12 N13 2.57e-02
C14 N13 N14 1.66e-11
L14 N13 N14 5.36e-11
R14 N13 N14 5.92e+00
C15 N14 Port2 1.17e-11
L15 N14 Port2 3.06e-11
R15 N14 Port2 6.72e+00
.ENDS GRM21AR72A334KAC5
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/200[V]
* Murata P/N :GRM21AR72D102KW01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72D102KW01 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-10
R03 N02 N03 2.66e-01
C04 N03 N04 1.81e-08
R04 N03 N04 1.76e+02
C05 N04 N05 6.46e-08
R05 N04 N05 2.46e+00
C06 N05 N06 3.69e-08
R06 N05 N06 4.80e-01
C07 N06 N07 1.05e-08
R07 N06 N07 1.89e-01
L08 N07 N08 5.86e-11
R08 N07 N08 2.46e-01
C09 N08 N09 2.90e-12
L09 N08 N09 9.34e-11
R09 N08 N09 2.19e+01
C10 N09 N10 4.87e-12
L10 N09 N10 1.09e-10
R10 N09 N10 1.18e+01
C11 N10 Port2 7.11e-12
L11 N10 Port2 2.72e-10
R11 N10 Port2 1.64e+01
.ENDS GRM21AR72D102KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/200[V]
* Murata P/N :GRM21AR72D152KW01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72D152KW01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 2.31e-01
C04 N03 N04 3.78e-08
R04 N03 N04 8.42e+01
C05 N04 N05 1.08e-07
R05 N04 N05 2.11e+00
C06 N05 N06 7.77e-08
R06 N05 N06 4.66e-01
C07 N06 N07 2.06e-08
R07 N06 N07 1.93e-01
L08 N07 N08 3.90e-11
R08 N07 N08 3.23e-01
C09 N08 N09 3.64e-12
L09 N08 N09 7.44e-11
R09 N08 N09 1.75e+01
C10 N09 N10 4.66e-12
L10 N09 N10 1.25e-10
R10 N09 N10 1.22e+01
C11 N10 Port2 6.14e-12
L11 N10 Port2 3.37e-10
R11 N10 Port2 1.96e+01
.ENDS GRM21AR72D152KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/200[V]
* Murata P/N :GRM21AR72D222KW01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72D222KW01 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 1.69e-01
C04 N03 N04 6.88e-08
R04 N03 N04 4.63e+01
C05 N04 N05 1.58e-07
R05 N04 N05 1.44e+00
C06 N05 N06 1.06e-07
R06 N05 N06 3.40e-01
C07 N06 N07 3.66e-08
R07 N06 N07 1.17e-01
L08 N07 N08 8.15e-11
R08 N07 N08 5.12e-01
C09 N08 N09 2.89e-12
L09 N08 N09 9.37e-11
R09 N08 N09 2.20e+01
C10 N09 N10 4.38e-12
L10 N09 N10 1.33e-10
R10 N09 N10 1.30e+01
C11 N10 Port2 6.22e-12
L11 N10 Port2 2.68e-10
R11 N10 Port2 1.65e+01
.ENDS GRM21AR72D222KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/200[V]
* Murata P/N :GRM21AR72D332KW01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72D332KW01 Port1 Port2
C01 Port1 N01 3.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 1.43e-01
C04 N03 N04 1.22e-07
R04 N03 N04 2.61e+01
C05 N04 N05 2.28e-07
R05 N04 N05 1.27e+00
C06 N05 N06 1.85e-07
R06 N05 N06 2.52e-01
C07 N06 N07 8.55e-08
R07 N06 N07 8.46e-02
C08 N07 N08 1.36e-07
R08 N07 N08 1.95e-02
C09 N08 N09 2.70e-12
L09 N08 N09 1.56e-10
R09 N08 N09 1.47e+01
C10 N09 N10 3.84e-11
L10 N09 N10 1.83e-11
R10 N09 N10 4.43e+00
C11 N10 N11 5.10e-12
L11 N10 N11 3.63e-10
R11 N10 N11 2.17e+01
C12 N11 Port2 1.99e-09
L12 N11 Port2 2.59e-11
R12 N11 Port2 1.48e-01
.ENDS GRM21AR72D332KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/200[V]
* Murata P/N :GRM21AR72D472KW01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72D472KW01 Port1 Port2
C01 Port1 N01 4.66e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 1.25e-01
C04 N03 N04 2.04e-07
R04 N03 N04 1.30e+01
C05 N04 N05 3.67e-07
R05 N04 N05 6.67e-01
C06 N05 N06 2.83e-07
R06 N05 N06 1.65e-01
C07 N06 N07 1.69e-07
R07 N06 N07 4.28e-02
L08 N07 N08 5.07e-11
R08 N07 N08 3.19e-01
C09 N08 N09 3.55e-12
L09 N08 N09 7.63e-11
R09 N08 N09 1.79e+01
C10 N09 N10 3.17e-12
L10 N09 N10 1.68e-10
R10 N09 N10 1.41e+01
C11 N10 N11 8.17e-12
L11 N10 N11 2.20e-10
R11 N10 N11 1.63e+01
C12 N11 Port2 5.20e-09
L12 N11 Port2 2.14e-11
R12 N11 Port2 1.02e-01
.ENDS GRM21AR72D472KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/200[V]
* Murata P/N :GRM21AR72D682KW01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72D682KW01 Port1 Port2
C01 Port1 N01 6.42e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 9.01e-02
C04 N03 N04 3.37e-07
R04 N03 N04 7.88e+00
C05 N04 N05 5.45e-07
R05 N04 N05 4.87e-01
C06 N05 N06 4.57e-07
R06 N05 N06 1.02e-01
C07 N06 N07 2.11e-07
R07 N06 N07 4.44e-02
L08 N07 N08 6.17e-11
R08 N07 N08 1.86e-01
C09 N08 N09 2.45e-12
L09 N08 N09 1.11e-10
R09 N08 N09 2.60e+01
C10 N09 N10 4.89e-12
L10 N09 N10 1.06e-10
R10 N09 N10 1.17e+01
C11 N10 N11 7.81e-12
L11 N10 N11 1.84e-10
R11 N10 N11 1.72e+01
C12 N11 Port2 5.88e-09
L12 N11 Port2 3.29e-11
R12 N11 Port2 7.96e-02
.ENDS GRM21AR72D682KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/250[V]
* Murata P/N :GRM21AR72E102KW01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72E102KW01 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-10
R03 N02 N03 2.66e-01
C04 N03 N04 1.81e-08
R04 N03 N04 1.76e+02
C05 N04 N05 6.46e-08
R05 N04 N05 2.46e+00
C06 N05 N06 3.69e-08
R06 N05 N06 4.80e-01
C07 N06 N07 1.05e-08
R07 N06 N07 1.89e-01
L08 N07 N08 5.86e-11
R08 N07 N08 2.46e-01
C09 N08 N09 2.90e-12
L09 N08 N09 9.34e-11
R09 N08 N09 2.19e+01
C10 N09 N10 4.87e-12
L10 N09 N10 1.09e-10
R10 N09 N10 1.18e+01
C11 N10 Port2 7.11e-12
L11 N10 Port2 2.72e-10
R11 N10 Port2 1.64e+01
.ENDS GRM21AR72E102KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/250[V]
* Murata P/N :GRM21AR72E152KW01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72E152KW01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 2.31e-01
C04 N03 N04 3.78e-08
R04 N03 N04 8.42e+01
C05 N04 N05 1.08e-07
R05 N04 N05 2.11e+00
C06 N05 N06 7.77e-08
R06 N05 N06 4.66e-01
C07 N06 N07 2.06e-08
R07 N06 N07 1.93e-01
L08 N07 N08 3.90e-11
R08 N07 N08 3.23e-01
C09 N08 N09 3.64e-12
L09 N08 N09 7.44e-11
R09 N08 N09 1.75e+01
C10 N09 N10 4.66e-12
L10 N09 N10 1.25e-10
R10 N09 N10 1.22e+01
C11 N10 Port2 6.14e-12
L11 N10 Port2 3.37e-10
R11 N10 Port2 1.96e+01
.ENDS GRM21AR72E152KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/250[V]
* Murata P/N :GRM21AR72E222KW01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72E222KW01 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 1.69e-01
C04 N03 N04 6.88e-08
R04 N03 N04 4.63e+01
C05 N04 N05 1.58e-07
R05 N04 N05 1.44e+00
C06 N05 N06 1.06e-07
R06 N05 N06 3.40e-01
C07 N06 N07 3.66e-08
R07 N06 N07 1.17e-01
L08 N07 N08 8.15e-11
R08 N07 N08 5.12e-01
C09 N08 N09 2.89e-12
L09 N08 N09 9.37e-11
R09 N08 N09 2.20e+01
C10 N09 N10 4.38e-12
L10 N09 N10 1.33e-10
R10 N09 N10 1.30e+01
C11 N10 Port2 6.22e-12
L11 N10 Port2 2.68e-10
R11 N10 Port2 1.65e+01
.ENDS GRM21AR72E222KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/250[V]
* Murata P/N :GRM21AR72E332KW01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72E332KW01 Port1 Port2
C01 Port1 N01 3.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 1.43e-01
C04 N03 N04 1.22e-07
R04 N03 N04 2.61e+01
C05 N04 N05 2.28e-07
R05 N04 N05 1.27e+00
C06 N05 N06 1.85e-07
R06 N05 N06 2.52e-01
C07 N06 N07 8.55e-08
R07 N06 N07 8.46e-02
C08 N07 N08 1.36e-07
R08 N07 N08 1.95e-02
C09 N08 N09 2.70e-12
L09 N08 N09 1.56e-10
R09 N08 N09 1.47e+01
C10 N09 N10 3.84e-11
L10 N09 N10 1.83e-11
R10 N09 N10 4.43e+00
C11 N10 N11 5.10e-12
L11 N10 N11 3.63e-10
R11 N10 N11 2.17e+01
C12 N11 Port2 1.99e-09
L12 N11 Port2 2.59e-11
R12 N11 Port2 1.48e-01
.ENDS GRM21AR72E332KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/250[V]
* Murata P/N :GRM21AR72E472KW01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72E472KW01 Port1 Port2
C01 Port1 N01 4.66e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 1.25e-01
C04 N03 N04 2.04e-07
R04 N03 N04 1.30e+01
C05 N04 N05 3.67e-07
R05 N04 N05 6.67e-01
C06 N05 N06 2.83e-07
R06 N05 N06 1.65e-01
C07 N06 N07 1.69e-07
R07 N06 N07 4.28e-02
L08 N07 N08 5.07e-11
R08 N07 N08 3.19e-01
C09 N08 N09 3.55e-12
L09 N08 N09 7.63e-11
R09 N08 N09 1.79e+01
C10 N09 N10 3.17e-12
L10 N09 N10 1.68e-10
R10 N09 N10 1.41e+01
C11 N10 N11 8.17e-12
L11 N10 N11 2.20e-10
R11 N10 N11 1.63e+01
C12 N11 Port2 5.20e-09
L12 N11 Port2 2.14e-11
R12 N11 Port2 1.02e-01
.ENDS GRM21AR72E472KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/250[V]
* Murata P/N :GRM21AR72E682KW01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72E682KW01 Port1 Port2
C01 Port1 N01 6.42e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 9.01e-02
C04 N03 N04 3.37e-07
R04 N03 N04 7.88e+00
C05 N04 N05 5.45e-07
R05 N04 N05 4.87e-01
C06 N05 N06 4.57e-07
R06 N05 N06 1.02e-01
C07 N06 N07 2.11e-07
R07 N06 N07 4.44e-02
L08 N07 N08 6.17e-11
R08 N07 N08 1.86e-01
C09 N08 N09 2.45e-12
L09 N08 N09 1.11e-10
R09 N08 N09 2.60e+01
C10 N09 N10 4.89e-12
L10 N09 N10 1.06e-10
R10 N09 N10 1.17e+01
C11 N10 N11 7.81e-12
L11 N10 N11 1.84e-10
R11 N10 N11 1.72e+01
C12 N11 Port2 5.88e-09
L12 N11 Port2 3.29e-11
R12 N11 Port2 7.96e-02
.ENDS GRM21AR72E682KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/500[V]
* Murata P/N :GRM21AR72H102KW10
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72H102KW10 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-10
R03 N02 N03 2.66e-01
C04 N03 N04 1.81e-08
R04 N03 N04 1.76e+02
C05 N04 N05 6.46e-08
R05 N04 N05 2.46e+00
C06 N05 N06 3.69e-08
R06 N05 N06 4.80e-01
C07 N06 N07 1.05e-08
R07 N06 N07 1.89e-01
L08 N07 N08 5.86e-11
R08 N07 N08 2.46e-01
C09 N08 N09 2.90e-12
L09 N08 N09 9.34e-11
R09 N08 N09 2.19e+01
C10 N09 N10 4.87e-12
L10 N09 N10 1.09e-10
R10 N09 N10 1.18e+01
C11 N10 Port2 7.11e-12
L11 N10 Port2 2.72e-10
R11 N10 Port2 1.64e+01
.ENDS GRM21AR72H102KW10
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/500[V]
* Murata P/N :GRM21AR72H152KW10
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72H152KW10 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 2.31e-01
C04 N03 N04 3.78e-08
R04 N03 N04 8.42e+01
C05 N04 N05 1.08e-07
R05 N04 N05 2.11e+00
C06 N05 N06 7.77e-08
R06 N05 N06 4.66e-01
C07 N06 N07 2.06e-08
R07 N06 N07 1.93e-01
L08 N07 N08 3.90e-11
R08 N07 N08 3.23e-01
C09 N08 N09 3.64e-12
L09 N08 N09 7.44e-11
R09 N08 N09 1.75e+01
C10 N09 N10 4.66e-12
L10 N09 N10 1.25e-10
R10 N09 N10 1.22e+01
C11 N10 Port2 6.14e-12
L11 N10 Port2 3.37e-10
R11 N10 Port2 1.96e+01
.ENDS GRM21AR72H152KW10
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/500[V]
* Murata P/N :GRM21AR72H222KW10
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72H222KW10 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 1.69e-01
C04 N03 N04 6.88e-08
R04 N03 N04 4.63e+01
C05 N04 N05 1.58e-07
R05 N04 N05 1.44e+00
C06 N05 N06 1.06e-07
R06 N05 N06 3.40e-01
C07 N06 N07 3.66e-08
R07 N06 N07 1.17e-01
L08 N07 N08 8.15e-11
R08 N07 N08 5.12e-01
C09 N08 N09 2.89e-12
L09 N08 N09 9.37e-11
R09 N08 N09 2.20e+01
C10 N09 N10 4.38e-12
L10 N09 N10 1.33e-10
R10 N09 N10 1.30e+01
C11 N10 Port2 6.22e-12
L11 N10 Port2 2.68e-10
R11 N10 Port2 1.65e+01
.ENDS GRM21AR72H222KW10
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/500[V]
* Murata P/N :GRM21AR72H332KW10
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72H332KW10 Port1 Port2
C01 Port1 N01 3.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 1.43e-01
C04 N03 N04 1.22e-07
R04 N03 N04 2.61e+01
C05 N04 N05 2.28e-07
R05 N04 N05 1.27e+00
C06 N05 N06 1.85e-07
R06 N05 N06 2.52e-01
C07 N06 N07 8.55e-08
R07 N06 N07 8.46e-02
C08 N07 N08 1.36e-07
R08 N07 N08 1.95e-02
C09 N08 N09 2.70e-12
L09 N08 N09 1.56e-10
R09 N08 N09 1.47e+01
C10 N09 N10 3.84e-11
L10 N09 N10 1.83e-11
R10 N09 N10 4.43e+00
C11 N10 N11 5.10e-12
L11 N10 N11 3.63e-10
R11 N10 N11 2.17e+01
C12 N11 Port2 1.99e-09
L12 N11 Port2 2.59e-11
R12 N11 Port2 1.48e-01
.ENDS GRM21AR72H332KW10
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/500[V]
* Murata P/N :GRM21AR72H472KW10
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72H472KW10 Port1 Port2
C01 Port1 N01 4.66e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 1.25e-01
C04 N03 N04 2.04e-07
R04 N03 N04 1.30e+01
C05 N04 N05 3.67e-07
R05 N04 N05 6.67e-01
C06 N05 N06 2.83e-07
R06 N05 N06 1.65e-01
C07 N06 N07 1.69e-07
R07 N06 N07 4.28e-02
L08 N07 N08 5.07e-11
R08 N07 N08 3.19e-01
C09 N08 N09 3.55e-12
L09 N08 N09 7.63e-11
R09 N08 N09 1.79e+01
C10 N09 N10 3.17e-12
L10 N09 N10 1.68e-10
R10 N09 N10 1.41e+01
C11 N10 N11 8.17e-12
L11 N10 N11 2.20e-10
R11 N10 N11 1.63e+01
C12 N11 Port2 5.20e-09
L12 N11 Port2 2.14e-11
R12 N11 Port2 1.02e-01
.ENDS GRM21AR72H472KW10
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/500[V]
* Murata P/N :GRM21AR72H682KW10
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR72H682KW10 Port1 Port2
C01 Port1 N01 6.42e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 9.01e-02
C04 N03 N04 3.37e-07
R04 N03 N04 7.88e+00
C05 N04 N05 5.45e-07
R05 N04 N05 4.87e-01
C06 N05 N06 4.57e-07
R06 N05 N06 1.02e-01
C07 N06 N07 2.11e-07
R07 N06 N07 4.44e-02
L08 N07 N08 6.17e-11
R08 N07 N08 1.86e-01
C09 N08 N09 2.45e-12
L09 N08 N09 1.11e-10
R09 N08 N09 2.60e+01
C10 N09 N10 4.89e-12
L10 N09 N10 1.06e-10
R10 N09 N10 1.17e+01
C11 N10 N11 7.81e-12
L11 N10 N11 1.84e-10
R11 N10 N11 1.72e+01
C12 N11 Port2 5.88e-09
L12 N11 Port2 3.29e-11
R12 N11 Port2 7.96e-02
.ENDS GRM21AR72H682KW10
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/500[V]
* Murata P/N :GRM21AR7LU102KW01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR7LU102KW01 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-10
R03 N02 N03 2.66e-01
C04 N03 N04 1.81e-08
R04 N03 N04 1.76e+02
C05 N04 N05 6.46e-08
R05 N04 N05 2.46e+00
C06 N05 N06 3.69e-08
R06 N05 N06 4.80e-01
C07 N06 N07 1.05e-08
R07 N06 N07 1.89e-01
L08 N07 N08 5.86e-11
R08 N07 N08 2.46e-01
C09 N08 N09 2.90e-12
L09 N08 N09 9.34e-11
R09 N08 N09 2.19e+01
C10 N09 N10 4.87e-12
L10 N09 N10 1.09e-10
R10 N09 N10 1.18e+01
C11 N10 Port2 7.11e-12
L11 N10 Port2 2.72e-10
R11 N10 Port2 1.64e+01
.ENDS GRM21AR7LU102KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/500[V]
* Murata P/N :GRM21AR7LU152KW01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR7LU152KW01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 2.31e-01
C04 N03 N04 3.78e-08
R04 N03 N04 8.42e+01
C05 N04 N05 1.08e-07
R05 N04 N05 2.11e+00
C06 N05 N06 7.77e-08
R06 N05 N06 4.66e-01
C07 N06 N07 2.06e-08
R07 N06 N07 1.93e-01
L08 N07 N08 3.90e-11
R08 N07 N08 3.23e-01
C09 N08 N09 3.64e-12
L09 N08 N09 7.44e-11
R09 N08 N09 1.75e+01
C10 N09 N10 4.66e-12
L10 N09 N10 1.25e-10
R10 N09 N10 1.22e+01
C11 N10 Port2 6.14e-12
L11 N10 Port2 3.37e-10
R11 N10 Port2 1.96e+01
.ENDS GRM21AR7LU152KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/500[V]
* Murata P/N :GRM21AR7LU222KW01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR7LU222KW01 Port1 Port2
C01 Port1 N01 2.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 1.69e-01
C04 N03 N04 6.88e-08
R04 N03 N04 4.63e+01
C05 N04 N05 1.58e-07
R05 N04 N05 1.44e+00
C06 N05 N06 1.06e-07
R06 N05 N06 3.40e-01
C07 N06 N07 3.66e-08
R07 N06 N07 1.17e-01
L08 N07 N08 8.15e-11
R08 N07 N08 5.12e-01
C09 N08 N09 2.89e-12
L09 N08 N09 9.37e-11
R09 N08 N09 2.20e+01
C10 N09 N10 4.38e-12
L10 N09 N10 1.33e-10
R10 N09 N10 1.30e+01
C11 N10 Port2 6.22e-12
L11 N10 Port2 2.68e-10
R11 N10 Port2 1.65e+01
.ENDS GRM21AR7LU222KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/500[V]
* Murata P/N :GRM21AR7LU332KW01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR7LU332KW01 Port1 Port2
C01 Port1 N01 3.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 1.43e-01
C04 N03 N04 1.22e-07
R04 N03 N04 2.61e+01
C05 N04 N05 2.28e-07
R05 N04 N05 1.27e+00
C06 N05 N06 1.85e-07
R06 N05 N06 2.52e-01
C07 N06 N07 8.55e-08
R07 N06 N07 8.46e-02
C08 N07 N08 1.36e-07
R08 N07 N08 1.95e-02
C09 N08 N09 2.70e-12
L09 N08 N09 1.56e-10
R09 N08 N09 1.47e+01
C10 N09 N10 3.84e-11
L10 N09 N10 1.83e-11
R10 N09 N10 4.43e+00
C11 N10 N11 5.10e-12
L11 N10 N11 3.63e-10
R11 N10 N11 2.17e+01
C12 N11 Port2 1.99e-09
L12 N11 Port2 2.59e-11
R12 N11 Port2 1.48e-01
.ENDS GRM21AR7LU332KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/500[V]
* Murata P/N :GRM21AR7LU472KW01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR7LU472KW01 Port1 Port2
C01 Port1 N01 4.66e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 1.25e-01
C04 N03 N04 2.04e-07
R04 N03 N04 1.30e+01
C05 N04 N05 3.67e-07
R05 N04 N05 6.67e-01
C06 N05 N06 2.83e-07
R06 N05 N06 1.65e-01
C07 N06 N07 1.69e-07
R07 N06 N07 4.28e-02
L08 N07 N08 5.07e-11
R08 N07 N08 3.19e-01
C09 N08 N09 3.55e-12
L09 N08 N09 7.63e-11
R09 N08 N09 1.79e+01
C10 N09 N10 3.17e-12
L10 N09 N10 1.68e-10
R10 N09 N10 1.41e+01
C11 N10 N11 8.17e-12
L11 N10 N11 2.20e-10
R11 N10 N11 1.63e+01
C12 N11 Port2 5.20e-09
L12 N11 Port2 2.14e-11
R12 N11 Port2 1.02e-01
.ENDS GRM21AR7LU472KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/500[V]
* Murata P/N :GRM21AR7LU682KW01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21AR7LU682KW01 Port1 Port2
C01 Port1 N01 6.42e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 9.01e-02
C04 N03 N04 3.37e-07
R04 N03 N04 7.88e+00
C05 N04 N05 5.45e-07
R05 N04 N05 4.87e-01
C06 N05 N06 4.57e-07
R06 N05 N06 1.02e-01
C07 N06 N07 2.11e-07
R07 N06 N07 4.44e-02
L08 N07 N08 6.17e-11
R08 N07 N08 1.86e-01
C09 N08 N09 2.45e-12
L09 N08 N09 1.11e-10
R09 N08 N09 2.60e+01
C10 N09 N10 4.89e-12
L10 N09 N10 1.06e-10
R10 N09 N10 1.17e+01
C11 N10 N11 7.81e-12
L11 N10 N11 1.84e-10
R11 N10 N11 1.72e+01
C12 N11 Port2 5.88e-09
L12 N11 Port2 3.29e-11
R12 N11 Port2 7.96e-02
.ENDS GRM21AR7LU682KW01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :GRM21BB10J105KC01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB10J105KC01 Port1 Port2
C01 Port1 N01 9.65e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 2.25e-10
R03 N02 N03 4.51e-03
C04 N03 N04 8.44e-05
R04 N03 N04 6.29e+01
C05 N04 N05 1.37e-04
R05 N04 N05 2.85e+00
C06 N05 N06 1.25e-04
R06 N05 N06 3.66e-01
C07 N06 N07 1.22e-04
R07 N06 N07 4.44e-02
C08 N07 N08 1.15e-04
R08 N07 N08 7.22e-03
L09 N08 N09 2.95e-11
R09 N08 N09 1.28e-01
L10 N09 N10 2.05e-10
R10 N09 N10 3.43e-02
C11 N10 N11 4.48e-06
L11 N10 N11 3.70e-11
R11 N10 N11 1.50e-02
C12 N11 N12 1.55e-06
L12 N11 N12 5.13e-11
R12 N11 N12 1.74e-02
C13 N12 N13 7.56e-12
L13 N12 N13 8.71e-11
R13 N12 N13 9.19e+00
C14 N13 Port2 1.10e-11
L14 N13 Port2 3.44e-11
R14 N13 Port2 1.38e+01
.ENDS GRM21BB10J105KC01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRM21BB10J225KA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB10J225KA01 Port1 Port2
C01 Port1 N01 2.18e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 9.47e-11
R03 N02 N03 3.18e-03
C04 N03 N04 8.47e-05
R04 N03 N04 7.89e+01
C05 N04 N05 2.42e-04
R05 N04 N05 1.65e+00
C06 N05 N06 2.11e-04
R06 N05 N06 1.89e-01
C07 N06 N07 2.02e-04
R07 N06 N07 2.01e-02
C08 N07 N08 1.83e-04
R08 N07 N08 3.15e-03
L09 N08 N09 2.47e-11
R09 N08 N09 2.97e-02
L10 N09 N10 2.39e-10
R10 N09 N10 2.71e-02
C11 N10 N11 6.04e-06
L11 N10 N11 6.28e-11
R11 N10 N11 1.18e-02
C12 N11 N12 4.07e-06
L12 N11 N12 4.37e-11
R12 N11 N12 1.03e-02
C13 N12 N13 8.01e-12
L13 N12 N13 8.49e-11
R13 N12 N13 1.04e+01
C14 N13 Port2 2.97e-12
L14 N13 Port2 1.02e-10
R14 N13 Port2 2.55e+01
.ENDS GRM21BB10J225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRM21BB10J475KA11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB10J475KA11 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.72e-10
R03 N02 N03 3.96e-03
C04 N03 N04 4.93e-05
R04 N03 N04 1.13e+02
C05 N04 N05 9.27e-05
R05 N04 N05 3.89e+00
C06 N05 N06 8.77e-05
R06 N05 N06 4.03e-01
C07 N06 N07 6.58e-05
R07 N06 N07 5.09e-02
C08 N07 N08 6.31e-05
R08 N07 N08 5.54e-03
L09 N08 N09 9.24e-12
R09 N08 N09 5.25e-02
L10 N09 N10 2.82e-11
R10 N09 N10 2.91e-02
L11 N10 N11 2.89e-10
R11 N10 N11 2.35e-02
C12 N11 N12 9.87e-06
L12 N11 N12 5.10e-11
R12 N11 N12 8.09e-03
C13 N12 N13 9.42e-06
L13 N12 N13 2.60e-11
R13 N12 N13 6.28e-03
C14 N13 N14 1.16e-11
L14 N13 N14 5.80e-11
R14 N13 N14 7.91e+00
C15 N14 Port2 3.04e-11
L15 N14 Port2 1.41e-11
R15 N14 Port2 2.76e+00
.ENDS GRM21BB10J475KA11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRM21BB10J475MA11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB10J475MA11 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.72e-10
R03 N02 N03 3.96e-03
C04 N03 N04 4.93e-05
R04 N03 N04 1.13e+02
C05 N04 N05 9.27e-05
R05 N04 N05 3.89e+00
C06 N05 N06 8.77e-05
R06 N05 N06 4.03e-01
C07 N06 N07 6.58e-05
R07 N06 N07 5.09e-02
C08 N07 N08 6.31e-05
R08 N07 N08 5.54e-03
L09 N08 N09 9.24e-12
R09 N08 N09 5.25e-02
L10 N09 N10 2.82e-11
R10 N09 N10 2.91e-02
L11 N10 N11 2.89e-10
R11 N10 N11 2.35e-02
C12 N11 N12 9.87e-06
L12 N11 N12 5.10e-11
R12 N11 N12 8.09e-03
C13 N12 N13 9.42e-06
L13 N12 N13 2.60e-11
R13 N12 N13 6.28e-03
C14 N13 N14 1.16e-11
L14 N13 N14 5.80e-11
R14 N13 N14 7.91e+00
C15 N14 Port2 3.04e-11
L15 N14 Port2 1.41e-11
R15 N14 Port2 2.76e+00
.ENDS GRM21BB10J475MA11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRM21BB11A105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11A105KA01 Port1 Port2
C01 Port1 N01 9.33e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.89e-10
R03 N02 N03 4.90e-03
C04 N03 N04 1.81e-04
R04 N03 N04 6.47e+00
C05 N04 N05 1.23e-04
R05 N04 N05 7.97e-01
C06 N05 N06 1.13e-04
R06 N05 N06 9.92e-02
C07 N06 N07 7.87e-05
R07 N06 N07 1.33e-02
L08 N07 N08 1.81e-11
R08 N07 N08 5.44e-02
L09 N08 N09 1.88e-10
R09 N08 N09 3.80e-02
C10 N09 N10 3.05e-06
L10 N09 N10 5.20e-11
R10 N09 N10 1.67e-02
C11 N10 N11 1.74e-06
L11 N10 N11 4.23e-11
R11 N10 N11 1.75e-02
C12 N11 N12 8.19e-12
L12 N11 N12 9.37e-11
R12 N11 N12 1.03e+01
C13 N12 Port2 5.87e-12
L13 N12 Port2 5.67e-11
R13 N12 Port2 1.96e+01
.ENDS GRM21BB11A105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRM21BB11A225KA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11A225KA01 Port1 Port2
C01 Port1 N01 2.09e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.45e-10
R03 N02 N03 3.55e-03
C04 N03 N04 3.21e-04
R04 N03 N04 3.17e+00
C05 N04 N05 2.43e-04
R05 N04 N05 4.88e-01
C06 N05 N06 2.20e-04
R06 N05 N06 6.27e-02
C07 N06 N07 1.58e-04
R07 N06 N07 8.68e-03
L08 N07 N08 2.33e-11
R08 N07 N08 4.78e-02
L09 N08 N09 2.49e-10
R09 N08 N09 3.03e-02
C10 N09 N10 8.74e-06
L10 N09 N10 4.58e-11
R10 N09 N10 1.10e-02
C11 N10 N11 2.72e-06
L11 N10 N11 6.86e-11
R11 N10 N11 1.15e-02
C12 N11 N12 1.30e-11
L12 N11 N12 6.01e-11
R12 N11 N12 5.50e+00
C13 N12 Port2 4.00e-12
L13 N12 Port2 6.72e-11
R13 N12 Port2 1.84e+01
.ENDS GRM21BB11A225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRM21BB11A225MA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11A225MA01 Port1 Port2
C01 Port1 N01 2.09e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.45e-10
R03 N02 N03 3.55e-03
C04 N03 N04 3.21e-04
R04 N03 N04 3.17e+00
C05 N04 N05 2.43e-04
R05 N04 N05 4.88e-01
C06 N05 N06 2.20e-04
R06 N05 N06 6.27e-02
C07 N06 N07 1.58e-04
R07 N06 N07 8.68e-03
L08 N07 N08 2.33e-11
R08 N07 N08 4.78e-02
L09 N08 N09 2.49e-10
R09 N08 N09 3.03e-02
C10 N09 N10 8.74e-06
L10 N09 N10 4.58e-11
R10 N09 N10 1.10e-02
C11 N10 N11 2.72e-06
L11 N10 N11 6.86e-11
R11 N10 N11 1.15e-02
C12 N11 N12 1.30e-11
L12 N11 N12 6.01e-11
R12 N11 N12 5.50e+00
C13 N12 Port2 4.00e-12
L13 N12 Port2 6.72e-11
R13 N12 Port2 1.84e+01
.ENDS GRM21BB11A225MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRM21BB11C105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11C105KA01 Port1 Port2
C01 Port1 N01 9.33e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.89e-10
R03 N02 N03 4.90e-03
C04 N03 N04 1.81e-04
R04 N03 N04 6.47e+00
C05 N04 N05 1.23e-04
R05 N04 N05 7.97e-01
C06 N05 N06 1.13e-04
R06 N05 N06 9.92e-02
C07 N06 N07 7.87e-05
R07 N06 N07 1.33e-02
L08 N07 N08 1.81e-11
R08 N07 N08 5.44e-02
L09 N08 N09 1.88e-10
R09 N08 N09 3.80e-02
C10 N09 N10 3.05e-06
L10 N09 N10 5.20e-11
R10 N09 N10 1.67e-02
C11 N10 N11 1.74e-06
L11 N10 N11 4.23e-11
R11 N10 N11 1.75e-02
C12 N11 N12 8.19e-12
L12 N11 N12 9.37e-11
R12 N11 N12 1.03e+01
C13 N12 Port2 5.87e-12
L13 N12 Port2 5.67e-11
R13 N12 Port2 1.96e+01
.ENDS GRM21BB11C105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GRM21BB11C224KA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11C224KA01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 8.13e-11
R03 N02 N03 1.05e-02
C04 N03 N04 3.32e-05
R04 N03 N04 1.20e+02
C05 N04 N05 7.33e-05
R05 N04 N05 1.14e+01
C06 N05 N06 4.01e-05
R06 N05 N06 5.11e+00
C07 N06 N07 4.58e-05
R07 N06 N07 7.56e-01
C08 N07 N08 3.44e-05
R08 N07 N08 1.81e-01
C09 N08 N09 3.92e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.87e-05
R10 N09 N10 1.34e-02
C11 N10 N11 1.98e-05
R11 N10 N11 1.69e-03
C12 N11 N12 5.30e+00
R12 N11 N12 3.00e-06
L13 N12 N13 1.37e-10
R13 N12 N13 5.78e-02
C14 N13 N14 1.22e-06
L14 N13 N14 2.66e-11
R14 N13 N14 1.76e-02
C15 N14 N15 3.20e-07
L15 N14 N15 4.28e-11
R15 N14 N15 2.44e-02
C16 N15 N16 8.80e-12
L16 N15 N16 1.19e-10
R16 N15 N16 9.16e+00
C17 N16 Port2 1.40e-12
L17 N16 Port2 2.16e-10
R17 N16 Port2 2.71e+01
.ENDS GRM21BB11C224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GRM21BB11C224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11C224MA01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 8.13e-11
R03 N02 N03 1.05e-02
C04 N03 N04 3.32e-05
R04 N03 N04 1.20e+02
C05 N04 N05 7.33e-05
R05 N04 N05 1.14e+01
C06 N05 N06 4.01e-05
R06 N05 N06 5.11e+00
C07 N06 N07 4.58e-05
R07 N06 N07 7.56e-01
C08 N07 N08 3.44e-05
R08 N07 N08 1.81e-01
C09 N08 N09 3.92e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.87e-05
R10 N09 N10 1.34e-02
C11 N10 N11 1.98e-05
R11 N10 N11 1.69e-03
C12 N11 N12 5.30e+00
R12 N11 N12 3.00e-06
L13 N12 N13 1.37e-10
R13 N12 N13 5.78e-02
C14 N13 N14 1.22e-06
L14 N13 N14 2.66e-11
R14 N13 N14 1.76e-02
C15 N14 N15 3.20e-07
L15 N14 N15 4.28e-11
R15 N14 N15 2.44e-02
C16 N15 N16 8.80e-12
L16 N15 N16 1.19e-10
R16 N15 N16 9.16e+00
C17 N16 Port2 1.40e-12
L17 N16 Port2 2.16e-10
R17 N16 Port2 2.71e+01
.ENDS GRM21BB11C224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GRM21BB11E154KA01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11E154KA01 Port1 Port2
C01 Port1 N01 1.49e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 2.16e-10
R03 N02 N03 1.36e-02
C04 N03 N04 1.98e-05
R04 N03 N04 2.01e+02
C05 N04 N05 3.78e-05
R05 N04 N05 1.91e+01
C06 N05 N06 2.60e-05
R06 N05 N06 4.70e+00
C07 N06 N07 2.69e-05
R07 N06 N07 7.11e-01
C08 N07 N08 2.02e-05
R08 N07 N08 1.22e-01
C09 N08 N09 9.76e-06
R09 N08 N09 2.24e-02
L10 N09 N10 1.41e-10
R10 N09 N10 6.41e-02
L11 N10 N11 8.96e-12
R11 N10 N11 2.99e-02
C12 N11 N12 9.52e-07
L12 N11 N12 2.55e-11
R12 N11 N12 1.77e-02
C13 N12 N13 2.56e-07
L13 N12 N13 3.19e-11
R13 N12 N13 2.07e-02
C14 N13 N14 7.73e-12
L14 N13 N14 1.42e-10
R14 N13 N14 1.07e+01
C15 N14 Port2 4.83e-12
L15 N14 Port2 6.46e-11
R15 N14 Port2 2.55e+01
.ENDS GRM21BB11E154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRM21BB11E224KA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11E224KA01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 8.13e-11
R03 N02 N03 1.05e-02
C04 N03 N04 3.32e-05
R04 N03 N04 1.20e+02
C05 N04 N05 7.33e-05
R05 N04 N05 1.14e+01
C06 N05 N06 4.01e-05
R06 N05 N06 5.11e+00
C07 N06 N07 4.58e-05
R07 N06 N07 7.56e-01
C08 N07 N08 3.44e-05
R08 N07 N08 1.81e-01
C09 N08 N09 3.92e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.87e-05
R10 N09 N10 1.34e-02
C11 N10 N11 1.98e-05
R11 N10 N11 1.69e-03
C12 N11 N12 5.30e+00
R12 N11 N12 3.00e-06
L13 N12 N13 1.37e-10
R13 N12 N13 5.78e-02
C14 N13 N14 1.22e-06
L14 N13 N14 2.66e-11
R14 N13 N14 1.76e-02
C15 N14 N15 3.20e-07
L15 N14 N15 4.28e-11
R15 N14 N15 2.44e-02
C16 N15 N16 8.80e-12
L16 N15 N16 1.19e-10
R16 N15 N16 9.16e+00
C17 N16 Port2 1.40e-12
L17 N16 Port2 2.16e-10
R17 N16 Port2 2.71e+01
.ENDS GRM21BB11E224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRM21BB11E224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11E224MA01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 8.13e-11
R03 N02 N03 1.05e-02
C04 N03 N04 3.32e-05
R04 N03 N04 1.20e+02
C05 N04 N05 7.33e-05
R05 N04 N05 1.14e+01
C06 N05 N06 4.01e-05
R06 N05 N06 5.11e+00
C07 N06 N07 4.58e-05
R07 N06 N07 7.56e-01
C08 N07 N08 3.44e-05
R08 N07 N08 1.81e-01
C09 N08 N09 3.92e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.87e-05
R10 N09 N10 1.34e-02
C11 N10 N11 1.98e-05
R11 N10 N11 1.69e-03
C12 N11 N12 5.30e+00
R12 N11 N12 3.00e-06
L13 N12 N13 1.37e-10
R13 N12 N13 5.78e-02
C14 N13 N14 1.22e-06
L14 N13 N14 2.66e-11
R14 N13 N14 1.76e-02
C15 N14 N15 3.20e-07
L15 N14 N15 4.28e-11
R15 N14 N15 2.44e-02
C16 N15 N16 8.80e-12
L16 N15 N16 1.19e-10
R16 N15 N16 9.16e+00
C17 N16 Port2 1.40e-12
L17 N16 Port2 2.16e-10
R17 N16 Port2 2.71e+01
.ENDS GRM21BB11E224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/3.30e-01[uF]/25[V]
* Murata P/N :GRM21BB11E334KA01
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11E334KA01 Port1 Port2
C01 Port1 N01 3.19e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.07e-10
R03 N02 N03 6.23e-03
C04 N03 N04 4.27e-05
R04 N03 N04 9.32e+01
C05 N04 N05 7.24e-05
R05 N04 N05 9.99e+00
C06 N05 N06 5.76e-05
R06 N05 N06 2.14e+00
C07 N06 N07 8.51e-05
R07 N06 N07 2.09e-01
C08 N07 N08 6.33e-05
R08 N07 N08 1.12e-01
C09 N08 N09 2.78e-05
R09 N08 N09 2.45e-02
L10 N09 N10 1.96e-10
R10 N09 N10 5.77e-02
L11 N10 N11 1.15e-11
R11 N10 N11 4.08e-02
C12 N11 N12 1.36e-06
L12 N11 N12 4.23e-11
R12 N11 N12 2.86e-02
C13 N12 N13 5.96e-07
L13 N12 N13 4.49e-11
R13 N12 N13 3.17e-02
C14 N13 N14 1.79e-11
L14 N13 N14 4.55e-11
R14 N13 N14 7.14e+00
C15 N14 Port2 1.74e-12
L15 N14 Port2 1.72e-10
R15 N14 Port2 2.46e+01
.ENDS GRM21BB11E334KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRM21BB11H104KA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11H104KA01 Port1 Port2
C01 Port1 N01 9.67e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 7.66e-11
R03 N02 N03 1.45e-02
C04 N03 N04 1.59e-05
R04 N03 N04 2.50e+02
C05 N04 N05 2.80e-05
R05 N04 N05 2.22e+01
C06 N05 N06 1.82e-05
R06 N05 N06 7.71e+00
C07 N06 N07 1.87e-05
R07 N06 N07 1.01e+00
C08 N07 N08 4.13e-05
R08 N07 N08 1.93e-01
C09 N08 N09 2.21e-05
R09 N08 N09 7.70e-02
C10 N09 N10 1.37e-05
R10 N09 N10 3.92e-02
C11 N10 N11 7.58e-06
R11 N10 N11 1.26e-02
L12 N11 N12 4.51e-11
R12 N11 N12 2.65e-01
L13 N12 N13 1.20e-10
R13 N12 N13 8.93e-02
C14 N13 N14 4.91e-07
L14 N13 N14 2.99e-11
R14 N13 N14 3.39e-02
C15 N14 N15 9.88e-08
L15 N14 N15 6.61e-11
R15 N14 N15 4.82e-02
C16 N15 N16 1.67e-11
L16 N15 N16 5.76e-11
R16 N15 N16 5.64e+00
C17 N16 N17 3.41e-12
L17 N16 N17 1.11e-10
R17 N16 N17 1.35e+01
C18 N17 Port2 1.95e-12
L18 N17 Port2 9.64e-11
R18 N17 Port2 1.00e+05
.ENDS GRM21BB11H104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRM21BB11H104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11H104MA01 Port1 Port2
C01 Port1 N01 9.67e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 7.66e-11
R03 N02 N03 1.45e-02
C04 N03 N04 1.59e-05
R04 N03 N04 2.50e+02
C05 N04 N05 2.80e-05
R05 N04 N05 2.22e+01
C06 N05 N06 1.82e-05
R06 N05 N06 7.71e+00
C07 N06 N07 1.87e-05
R07 N06 N07 1.01e+00
C08 N07 N08 4.13e-05
R08 N07 N08 1.93e-01
C09 N08 N09 2.21e-05
R09 N08 N09 7.70e-02
C10 N09 N10 1.37e-05
R10 N09 N10 3.92e-02
C11 N10 N11 7.58e-06
R11 N10 N11 1.26e-02
L12 N11 N12 4.51e-11
R12 N11 N12 2.65e-01
L13 N12 N13 1.20e-10
R13 N12 N13 8.93e-02
C14 N13 N14 4.91e-07
L14 N13 N14 2.99e-11
R14 N13 N14 3.39e-02
C15 N14 N15 9.88e-08
L15 N14 N15 6.61e-11
R15 N14 N15 4.82e-02
C16 N15 N16 1.67e-11
L16 N15 N16 5.76e-11
R16 N15 N16 5.64e+00
C17 N16 N17 3.41e-12
L17 N16 N17 1.11e-10
R17 N16 N17 1.35e+01
C18 N17 Port2 1.95e-12
L18 N17 Port2 9.64e-11
R18 N17 Port2 1.00e+05
.ENDS GRM21BB11H104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRM21BB11H473KA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11H473KA01 Port1 Port2
C01 Port1 N01 4.69e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 2.04e-02
C04 N03 N04 6.37e-06
R04 N03 N04 5.38e+02
C05 N04 N05 7.89e-06
R05 N04 N05 6.33e+01
C06 N05 N06 6.97e-06
R06 N05 N06 8.34e+00
C07 N06 N07 8.44e-06
R07 N06 N07 9.13e-01
C08 N07 N08 6.32e-06
R08 N07 N08 2.80e-01
C09 N08 N09 3.65e-06
R09 N08 N09 6.23e-02
C10 N09 N10 2.57e-06
R10 N09 N10 1.34e-02
L11 N10 N11 1.02e-10
R11 N10 N11 1.45e-01
C12 N11 N12 2.32e-07
L12 N11 N12 3.18e-11
R12 N11 N12 4.95e-02
C13 N12 N13 3.38e-08
L13 N12 N13 6.26e-11
R13 N12 N13 5.68e-02
C14 N13 N14 1.67e-11
L14 N13 N14 7.82e-11
R14 N13 N14 6.21e+00
C15 N14 Port2 1.83e-12
L15 N14 Port2 1.62e-10
R15 N14 Port2 2.25e+01
.ENDS GRM21BB11H473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRM21BB11H473MA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11H473MA01 Port1 Port2
C01 Port1 N01 4.69e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 2.04e-02
C04 N03 N04 6.37e-06
R04 N03 N04 5.38e+02
C05 N04 N05 7.89e-06
R05 N04 N05 6.33e+01
C06 N05 N06 6.97e-06
R06 N05 N06 8.34e+00
C07 N06 N07 8.44e-06
R07 N06 N07 9.13e-01
C08 N07 N08 6.32e-06
R08 N07 N08 2.80e-01
C09 N08 N09 3.65e-06
R09 N08 N09 6.23e-02
C10 N09 N10 2.57e-06
R10 N09 N10 1.34e-02
L11 N10 N11 1.02e-10
R11 N10 N11 1.45e-01
C12 N11 N12 2.32e-07
L12 N11 N12 3.18e-11
R12 N11 N12 4.95e-02
C13 N12 N13 3.38e-08
L13 N12 N13 6.26e-11
R13 N12 N13 5.68e-02
C14 N13 N14 1.67e-11
L14 N13 N14 7.82e-11
R14 N13 N14 6.21e+00
C15 N14 Port2 1.83e-12
L15 N14 Port2 1.62e-10
R15 N14 Port2 2.25e+01
.ENDS GRM21BB11H473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GRM21BB11H683KA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB11H683KA01 Port1 Port2
C01 Port1 N01 6.81e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.71e-10
R03 N02 N03 1.98e-02
C04 N03 N04 9.16e-06
R04 N03 N04 4.03e+02
C05 N04 N05 1.40e-05
R05 N04 N05 4.13e+01
C06 N05 N06 1.12e-05
R06 N05 N06 8.43e+00
C07 N06 N07 1.02e-05
R07 N06 N07 1.11e+00
C08 N07 N08 9.18e-06
R08 N07 N08 2.13e-01
C09 N08 N09 6.68e-06
R09 N08 N09 4.00e-02
C10 N09 N10 3.17e-06
R10 N09 N10 1.22e-02
L11 N10 N11 1.31e-10
R11 N10 N11 1.07e-01
C12 N11 N12 6.53e-07
L12 N11 N12 1.65e-11
R12 N11 N12 2.41e-02
C13 N12 N13 6.83e-08
L13 N12 N13 7.25e-11
R13 N12 N13 4.98e-02
C14 N13 N14 8.68e-12
L14 N13 N14 1.29e-10
R14 N13 N14 9.84e+00
C15 N14 Port2 3.88e-12
L15 N14 Port2 9.77e-11
R15 N14 Port2 2.08e+01
.ENDS GRM21BB11H683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+01[uF]/4[V]
* Murata P/N :GRM21BB30G476ME15
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB30G476ME15 Port1 Port2
C01 Port1 N01 3.55e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 9.05e-11
R03 N02 N03 1.62e-03
C04 N03 N04 1.31e-03
R04 N03 N04 4.05e+00
C05 N04 N05 1.75e-03
R05 N04 N05 3.57e-01
C06 N05 N06 2.34e-03
R06 N05 N06 2.90e-02
C07 N06 N07 2.97e-03
R07 N06 N07 2.18e-03
L08 N07 N08 1.39e-11
R08 N07 N08 6.34e-02
L09 N08 N09 6.62e-11
R09 N08 N09 2.53e-02
L10 N09 N10 3.97e-10
R10 N09 N10 9.41e-03
C11 N10 N11 3.11e-05
L11 N10 N11 2.18e-10
R11 N10 N11 2.51e-03
C12 N11 N12 2.00e-11
L12 N11 N12 5.83e-11
R12 N11 N12 6.42e+00
C13 N12 Port2 2.17e-12
L13 N12 Port2 1.22e-10
R13 N12 Port2 2.59e+01
.ENDS GRM21BB30G476ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM21BB30J106KE18
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB30J106KE18 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BB30J106KE18
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM21BB30J106ME18
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB30J106ME18 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BB30J106ME18
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRM21BB30J226ME38
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB30J226ME38 Port1 Port2
C01 Port1 N01 1.41e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.44e-10
R03 N02 N03 2.43e-03
C04 N03 N04 2.83e-04
R04 N03 N04 2.01e+01
C05 N04 N05 3.85e-04
R05 N04 N05 1.39e+00
C06 N05 N06 3.52e-04
R06 N05 N06 1.52e-01
C07 N06 N07 2.64e-04
R07 N06 N07 1.93e-02
C08 N07 N08 3.46e-04
R08 N07 N08 1.96e-03
L09 N08 N09 1.53e-11
R09 N08 N09 8.38e-02
L10 N09 N10 4.59e-11
R10 N09 N10 2.50e-02
L11 N10 N11 3.75e-10
R11 N10 N11 1.39e-02
C12 N11 N12 3.43e-05
L12 N11 N12 7.23e-11
R12 N11 N12 3.39e-03
C13 N12 N13 7.50e-05
L13 N12 N13 1.79e-11
R13 N12 N13 2.21e-03
C14 N13 N14 1.45e-11
L14 N13 N14 5.81e-11
R14 N13 N14 7.85e+00
C15 N14 Port2 8.35e-12
L15 N14 Port2 3.97e-11
R15 N14 Port2 5.40e+00
.ENDS GRM21BB30J226ME38
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRM21BB30J476ME15
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB30J476ME15 Port1 Port2
C01 Port1 N01 3.55e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 9.05e-11
R03 N02 N03 1.62e-03
C04 N03 N04 1.31e-03
R04 N03 N04 4.05e+00
C05 N04 N05 1.75e-03
R05 N04 N05 3.57e-01
C06 N05 N06 2.34e-03
R06 N05 N06 2.90e-02
C07 N06 N07 2.97e-03
R07 N06 N07 2.18e-03
L08 N07 N08 1.39e-11
R08 N07 N08 6.34e-02
L09 N08 N09 6.62e-11
R09 N08 N09 2.53e-02
L10 N09 N10 3.97e-10
R10 N09 N10 9.41e-03
C11 N10 N11 3.11e-05
L11 N10 N11 2.18e-10
R11 N10 N11 2.51e-03
C12 N11 N12 2.00e-11
L12 N11 N12 5.83e-11
R12 N11 N12 6.42e+00
C13 N12 Port2 2.17e-12
L13 N12 Port2 1.22e-10
R13 N12 Port2 2.59e+01
.ENDS GRM21BB30J476ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM21BB31A106KE18
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31A106KE18 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BB31A106KE18
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM21BB31A106ME18
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31A106ME18 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BB31A106ME18
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRM21BB31A226ME51
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31A226ME51 Port1 Port2
C01 Port1 N01 1.39e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.30e-10
R03 N02 N03 2.82e-03
C04 N03 N04 2.65e-04
R04 N03 N04 2.09e+01
C05 N04 N05 3.55e-04
R05 N04 N05 1.46e+00
C06 N05 N06 3.16e-04
R06 N05 N06 1.66e-01
C07 N06 N07 3.15e-04
R07 N06 N07 1.69e-02
C08 N07 N08 3.14e-04
R08 N07 N08 3.37e-03
L09 N08 N09 1.24e-11
R09 N08 N09 7.31e-02
L10 N09 N10 4.63e-11
R10 N09 N10 2.87e-02
L11 N10 N11 3.31e-10
R11 N10 N11 1.45e-02
C12 N11 N12 3.75e-05
L12 N11 N12 6.73e-11
R12 N11 N12 2.86e-03
C13 N12 N13 2.57e-05
L13 N12 N13 4.91e-11
R13 N12 N13 2.48e-03
C14 N13 N14 1.19e-11
L14 N13 N14 6.42e-11
R14 N13 N14 8.47e+00
C15 N14 Port2 6.03e-12
L15 N14 Port2 4.85e-11
R15 N14 Port2 2.31e+01
.ENDS GRM21BB31A226ME51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM21BB31A475KA74
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31A475KA74 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.72e-10
R03 N02 N03 3.96e-03
C04 N03 N04 4.93e-05
R04 N03 N04 1.13e+02
C05 N04 N05 9.27e-05
R05 N04 N05 3.89e+00
C06 N05 N06 8.77e-05
R06 N05 N06 4.03e-01
C07 N06 N07 6.58e-05
R07 N06 N07 5.09e-02
C08 N07 N08 6.31e-05
R08 N07 N08 5.54e-03
L09 N08 N09 9.24e-12
R09 N08 N09 5.25e-02
L10 N09 N10 2.82e-11
R10 N09 N10 2.91e-02
L11 N10 N11 2.89e-10
R11 N10 N11 2.35e-02
C12 N11 N12 9.87e-06
L12 N11 N12 5.10e-11
R12 N11 N12 8.09e-03
C13 N12 N13 9.42e-06
L13 N12 N13 2.60e-11
R13 N12 N13 6.28e-03
C14 N13 N14 1.16e-11
L14 N13 N14 5.80e-11
R14 N13 N14 7.91e+00
C15 N14 Port2 3.04e-11
L15 N14 Port2 1.41e-11
R15 N14 Port2 2.76e+00
.ENDS GRM21BB31A475KA74
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM21BB31A475MA74
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31A475MA74 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.72e-10
R03 N02 N03 3.96e-03
C04 N03 N04 4.93e-05
R04 N03 N04 1.13e+02
C05 N04 N05 9.27e-05
R05 N04 N05 3.89e+00
C06 N05 N06 8.77e-05
R06 N05 N06 4.03e-01
C07 N06 N07 6.58e-05
R07 N06 N07 5.09e-02
C08 N07 N08 6.31e-05
R08 N07 N08 5.54e-03
L09 N08 N09 9.24e-12
R09 N08 N09 5.25e-02
L10 N09 N10 2.82e-11
R10 N09 N10 2.91e-02
L11 N10 N11 2.89e-10
R11 N10 N11 2.35e-02
C12 N11 N12 9.87e-06
L12 N11 N12 5.10e-11
R12 N11 N12 8.09e-03
C13 N12 N13 9.42e-06
L13 N12 N13 2.60e-11
R13 N12 N13 6.28e-03
C14 N13 N14 1.16e-11
L14 N13 N14 5.80e-11
R14 N13 N14 7.91e+00
C15 N14 Port2 3.04e-11
L15 N14 Port2 1.41e-11
R15 N14 Port2 2.76e+00
.ENDS GRM21BB31A475MA74
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM21BB31C106KE15
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31C106KE15 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BB31C106KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM21BB31C106ME15
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31C106ME15 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BB31C106ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRM21BB31C225KA87
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31C225KA87 Port1 Port2
C01 Port1 N01 1.65e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 7.14e-11
R03 N02 N03 5.67e-03
C04 N03 N04 2.63e-05
R04 N03 N04 2.01e+02
C05 N04 N05 4.26e-05
R05 N04 N05 7.12e+00
C06 N05 N06 3.99e-05
R06 N05 N06 6.91e-01
C07 N06 N07 3.03e-05
R07 N06 N07 9.36e-02
C08 N07 N08 2.45e-05
R08 N07 N08 1.11e-02
L09 N08 N09 1.74e-11
R09 N08 N09 2.85e-02
L10 N09 N10 1.81e-10
R10 N09 N10 2.66e-02
C11 N10 N11 6.55e-06
L11 N10 N11 2.93e-11
R11 N10 N11 7.55e-03
C12 N11 N12 2.70e-06
L12 N11 N12 3.14e-11
R12 N11 N12 1.00e-02
C13 N12 N13 7.79e-12
L13 N12 N13 1.48e-10
R13 N12 N13 2.12e+01
C14 N13 Port2 2.08e-12
L14 N13 Port2 1.84e-10
R14 N13 Port2 3.72e+01
.ENDS GRM21BB31C225KA87
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM21BB31C475KA87
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31C475KA87 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRM21BB31C475KA87
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/20[V]
* Murata P/N :GRM21BB31D106KE15
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31D106KE15 Port1 Port2
C01 Port1 N01 7.37e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.65e-10
R03 N02 N03 3.67e-03
C04 N03 N04 1.78e-04
R04 N03 N04 2.87e+01
C05 N04 N05 2.15e-04
R05 N04 N05 2.07e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.95e-01
C07 N06 N07 1.63e-04
R07 N06 N07 4.31e-02
C08 N07 N08 1.24e-04
R08 N07 N08 7.12e-03
L09 N08 N09 1.88e-11
R09 N08 N09 1.48e-01
L10 N09 N10 3.83e-11
R10 N09 N10 2.67e-02
L11 N10 N11 2.60e-10
R11 N10 N11 1.59e-02
C12 N11 N12 2.22e-05
L12 N11 N12 5.51e-11
R12 N11 N12 4.65e-03
C13 N12 N13 1.44e-05
L13 N12 N13 4.28e-11
R13 N12 N13 4.55e-03
C14 N13 N14 9.14e-12
L14 N13 N14 6.16e-11
R14 N13 N14 1.16e+01
C15 N14 Port2 7.96e-12
L15 N14 Port2 4.00e-11
R15 N14 Port2 2.00e+01
.ENDS GRM21BB31D106KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/20[V]
* Murata P/N :GRM21BB31D106ME15
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31D106ME15 Port1 Port2
C01 Port1 N01 7.37e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.65e-10
R03 N02 N03 3.67e-03
C04 N03 N04 1.78e-04
R04 N03 N04 2.87e+01
C05 N04 N05 2.15e-04
R05 N04 N05 2.07e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.95e-01
C07 N06 N07 1.63e-04
R07 N06 N07 4.31e-02
C08 N07 N08 1.24e-04
R08 N07 N08 7.12e-03
L09 N08 N09 1.88e-11
R09 N08 N09 1.48e-01
L10 N09 N10 3.83e-11
R10 N09 N10 2.67e-02
L11 N10 N11 2.60e-10
R11 N10 N11 1.59e-02
C12 N11 N12 2.22e-05
L12 N11 N12 5.51e-11
R12 N11 N12 4.65e-03
C13 N12 N13 1.44e-05
L13 N12 N13 4.28e-11
R13 N12 N13 4.55e-03
C14 N13 N14 9.14e-12
L14 N13 N14 6.16e-11
R14 N13 N14 1.16e+01
C15 N14 Port2 7.96e-12
L15 N14 Port2 4.00e-11
R15 N14 Port2 2.00e+01
.ENDS GRM21BB31D106ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRM21BB31E105KA98
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31E105KA98 Port1 Port2
C01 Port1 N01 1.02e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 1.06e-10
R03 N02 N03 4.89e-03
C04 N03 N04 2.36e-05
R04 N03 N04 3.04e+02
C05 N04 N05 1.12e-04
R05 N04 N05 3.04e+00
C06 N05 N06 1.14e-04
R06 N05 N06 3.00e-01
C07 N06 N07 9.26e-05
R07 N06 N07 3.66e-02
C08 N07 N08 6.76e-05
R08 N07 N08 5.29e-03
L09 N08 N09 1.84e-11
R09 N08 N09 5.34e-02
L10 N09 N10 1.99e-10
R10 N09 N10 3.69e-02
C11 N10 N11 2.43e-06
L11 N10 N11 7.08e-11
R11 N10 N11 1.57e-02
C12 N11 N12 1.83e-06
L12 N11 N12 4.21e-11
R12 N11 N12 1.57e-02
C13 N12 N13 1.51e-11
L13 N12 N13 7.39e-11
R13 N12 N13 8.53e+00
C14 N13 Port2 2.10e-12
L14 N13 Port2 1.47e-10
R14 N13 Port2 2.33e+01
.ENDS GRM21BB31E105KA98
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM21BB31E106KA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31E106KA73 Port1 Port2
C01 Port1 N01 6.20e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.12e-10
R03 N02 N03 3.36e-03
C04 N03 N04 1.83e-04
R04 N03 N04 1.39e+01
C05 N04 N05 2.37e-04
R05 N04 N05 1.12e+00
C06 N05 N06 2.37e-04
R06 N05 N06 1.49e-01
C07 N06 N07 2.04e-04
R07 N06 N07 2.32e-02
C08 N07 N08 1.99e-04
R08 N07 N08 4.48e-03
L09 N08 N09 1.70e-11
R09 N08 N09 1.04e-01
L10 N09 N10 3.26e-11
R10 N09 N10 2.48e-02
L11 N10 N11 2.49e-10
R11 N10 N11 1.86e-02
C12 N11 N12 1.84e-05
L12 N11 N12 6.20e-11
R12 N11 N12 4.79e-03
C13 N12 N13 1.22e-05
L13 N12 N13 4.65e-11
R13 N12 N13 3.76e-03
C14 N13 Port2 8.91e-12
L14 N13 Port2 7.96e-11
R14 N13 Port2 1.34e+01
.ENDS GRM21BB31E106KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM21BB31E106MA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31E106MA73 Port1 Port2
C01 Port1 N01 6.20e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.12e-10
R03 N02 N03 3.36e-03
C04 N03 N04 1.83e-04
R04 N03 N04 1.39e+01
C05 N04 N05 2.37e-04
R05 N04 N05 1.12e+00
C06 N05 N06 2.37e-04
R06 N05 N06 1.49e-01
C07 N06 N07 2.04e-04
R07 N06 N07 2.32e-02
C08 N07 N08 1.99e-04
R08 N07 N08 4.48e-03
L09 N08 N09 1.70e-11
R09 N08 N09 1.04e-01
L10 N09 N10 3.26e-11
R10 N09 N10 2.48e-02
L11 N10 N11 2.49e-10
R11 N10 N11 1.86e-02
C12 N11 N12 1.84e-05
L12 N11 N12 6.20e-11
R12 N11 N12 4.79e-03
C13 N12 N13 1.22e-05
L13 N12 N13 4.65e-11
R13 N12 N13 3.76e-03
C14 N13 Port2 8.91e-12
L14 N13 Port2 7.96e-11
R14 N13 Port2 1.34e+01
.ENDS GRM21BB31E106MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM21BB31E225KA75
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31E225KA75 Port1 Port2
C01 Port1 N01 1.65e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 7.14e-11
R03 N02 N03 5.67e-03
C04 N03 N04 2.63e-05
R04 N03 N04 2.01e+02
C05 N04 N05 4.26e-05
R05 N04 N05 7.12e+00
C06 N05 N06 3.99e-05
R06 N05 N06 6.91e-01
C07 N06 N07 3.03e-05
R07 N06 N07 9.36e-02
C08 N07 N08 2.45e-05
R08 N07 N08 1.11e-02
L09 N08 N09 1.74e-11
R09 N08 N09 2.85e-02
L10 N09 N10 1.81e-10
R10 N09 N10 2.66e-02
C11 N10 N11 6.55e-06
L11 N10 N11 2.93e-11
R11 N10 N11 7.55e-03
C12 N11 N12 2.70e-06
L12 N11 N12 3.14e-11
R12 N11 N12 1.00e-02
C13 N12 N13 7.79e-12
L13 N12 N13 1.48e-10
R13 N12 N13 2.12e+01
C14 N13 Port2 2.08e-12
L14 N13 Port2 1.84e-10
R14 N13 Port2 3.72e+01
.ENDS GRM21BB31E225KA75
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM21BB31E225MA75
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31E225MA75 Port1 Port2
C01 Port1 N01 1.65e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 7.14e-11
R03 N02 N03 5.67e-03
C04 N03 N04 2.63e-05
R04 N03 N04 2.01e+02
C05 N04 N05 4.26e-05
R05 N04 N05 7.12e+00
C06 N05 N06 3.99e-05
R06 N05 N06 6.91e-01
C07 N06 N07 3.03e-05
R07 N06 N07 9.36e-02
C08 N07 N08 2.45e-05
R08 N07 N08 1.11e-02
L09 N08 N09 1.74e-11
R09 N08 N09 2.85e-02
L10 N09 N10 1.81e-10
R10 N09 N10 2.66e-02
C11 N10 N11 6.55e-06
L11 N10 N11 2.93e-11
R11 N10 N11 7.55e-03
C12 N11 N12 2.70e-06
L12 N11 N12 3.14e-11
R12 N11 N12 1.00e-02
C13 N12 N13 7.79e-12
L13 N12 N13 1.48e-10
R13 N12 N13 2.12e+01
C14 N13 Port2 2.08e-12
L14 N13 Port2 1.84e-10
R14 N13 Port2 3.72e+01
.ENDS GRM21BB31E225MA75
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRM21BB31E475KA75
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31E475KA75 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRM21BB31E475KA75
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRM21BB31E475MA75
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31E475MA75 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRM21BB31E475MA75
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRM21BB31H105KA12
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H105KA12 Port1 Port2
C01 Port1 N01 1.01e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 1.05e-10
R03 N02 N03 3.95e-03
C04 N03 N04 2.83e-05
R04 N03 N04 2.36e+02
C05 N04 N05 1.58e-04
R05 N04 N05 1.60e+00
C06 N05 N06 1.60e-04
R06 N05 N06 1.45e-01
C07 N06 N07 1.35e-04
R07 N06 N07 1.68e-02
C08 N07 N08 1.32e-04
R08 N07 N08 1.80e-03
L09 N08 N09 1.85e-10
R09 N08 N09 3.32e-02
L10 N09 N10 1.32e-11
R10 N09 N10 2.59e-02
C11 N10 N11 3.39e-06
L11 N10 N11 4.78e-11
R11 N10 N11 1.85e-02
C12 N11 N12 1.96e-06
L12 N11 N12 3.67e-11
R12 N11 N12 1.82e-02
C13 N12 N13 1.19e-11
L13 N12 N13 9.44e-11
R13 N12 N13 9.28e+00
C14 N13 Port2 2.35e-12
L14 N13 Port2 1.29e-10
R14 N13 Port2 1.85e+01
.ENDS GRM21BB31H105KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRM21BB31H105MA12
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H105MA12 Port1 Port2
C01 Port1 N01 9.39e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.89e-10
R03 N02 N03 4.20e-03
C04 N03 N04 2.65e-04
R04 N03 N04 1.50e+01
C05 N04 N05 3.96e-04
R05 N04 N05 1.66e+00
C06 N05 N06 2.76e-04
R06 N05 N06 4.58e-01
C07 N06 N07 1.89e-04
R07 N06 N07 9.91e-02
C08 N07 N08 1.52e-04
R08 N07 N08 1.58e-02
C09 N08 N09 3.22e-04
R09 N08 N09 1.94e-03
L10 N09 N10 2.38e-11
R10 N09 N10 7.83e-02
L11 N10 N11 2.31e-10
R11 N10 N11 3.87e-02
C12 N11 N12 3.52e-06
L12 N11 N12 4.72e-11
R12 N11 N12 1.52e-02
C13 N12 N13 2.26e-06
L13 N12 N13 3.52e-11
R13 N12 N13 1.51e-02
C14 N13 N14 1.80e-11
L14 N13 N14 6.17e-11
R14 N13 N14 6.01e+00
C15 N14 Port2 1.36e-11
L15 N14 Port2 2.94e-11
R15 N14 Port2 2.95e+00
.ENDS GRM21BB31H105MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.50e-01[uF]/50[V]
* Murata P/N :GRM21BB31H154KA88
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H154KA88 Port1 Port2
C01 Port1 N01 1.48e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.74e-10
R03 N02 N03 1.01e-02
C04 N03 N04 1.90e-05
R04 N03 N04 2.10e+02
C05 N04 N05 3.06e-05
R05 N04 N05 2.20e+01
C06 N05 N06 2.23e-05
R06 N05 N06 4.38e+00
C07 N06 N07 1.89e-05
R07 N06 N07 5.75e-01
C08 N07 N08 1.40e-05
R08 N07 N08 6.73e-02
C09 N08 N09 1.71e-05
R09 N08 N09 7.05e-03
C10 N09 N10 9.23e-06
R10 N09 N10 2.88e-03
L11 N10 N11 2.25e-11
R11 N10 N11 9.02e-02
L12 N11 N12 1.80e-10
R12 N11 N12 7.23e-02
C13 N12 N13 8.48e-07
L13 N12 N13 3.05e-11
R13 N12 N13 2.43e-02
C14 N13 N14 2.27e-07
L14 N13 N14 5.38e-11
R14 N13 N14 3.51e-02
C15 N14 N15 8.40e-12
L15 N14 N15 9.82e-11
R15 N14 N15 1.03e+01
C16 N15 Port2 4.19e-12
L16 N15 Port2 8.37e-11
R16 N15 Port2 1.58e+01
.ENDS GRM21BB31H154KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/1.50e-01[uF]/50[V]
* Murata P/N :GRM21BB31H154MA88
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H154MA88 Port1 Port2
C01 Port1 N01 1.48e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.74e-10
R03 N02 N03 1.01e-02
C04 N03 N04 1.90e-05
R04 N03 N04 2.10e+02
C05 N04 N05 3.06e-05
R05 N04 N05 2.20e+01
C06 N05 N06 2.23e-05
R06 N05 N06 4.38e+00
C07 N06 N07 1.89e-05
R07 N06 N07 5.75e-01
C08 N07 N08 1.40e-05
R08 N07 N08 6.73e-02
C09 N08 N09 1.71e-05
R09 N08 N09 7.05e-03
C10 N09 N10 9.23e-06
R10 N09 N10 2.88e-03
L11 N10 N11 2.25e-11
R11 N10 N11 9.02e-02
L12 N11 N12 1.80e-10
R12 N11 N12 7.23e-02
C13 N12 N13 8.48e-07
L13 N12 N13 3.05e-11
R13 N12 N13 2.43e-02
C14 N13 N14 2.27e-07
L14 N13 N14 5.38e-11
R14 N13 N14 3.51e-02
C15 N14 N15 8.40e-12
L15 N14 N15 9.82e-11
R15 N14 N15 1.03e+01
C16 N15 Port2 4.19e-12
L16 N15 Port2 8.37e-11
R16 N15 Port2 1.58e+01
.ENDS GRM21BB31H154MA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GRM21BB31H224KA88
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H224KA88 Port1 Port2
C01 Port1 N01 2.26e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.70e-10
R03 N02 N03 8.20e-03
C04 N03 N04 3.10e-05
R04 N03 N04 1.79e+02
C05 N04 N05 2.92e-05
R05 N04 N05 3.41e+01
C06 N05 N06 2.42e-05
R06 N05 N06 3.82e+00
C07 N06 N07 2.76e-05
R07 N06 N07 3.99e-01
C08 N07 N08 2.24e-05
R08 N07 N08 5.48e-02
C09 N08 N09 1.94e-05
R09 N08 N09 1.01e-02
L10 N09 N10 2.41e-11
R10 N09 N10 7.60e-02
L11 N10 N11 1.94e-10
R11 N10 N11 6.32e-02
C12 N11 N12 9.62e-07
L12 N11 N12 3.89e-11
R12 N11 N12 3.26e-02
C13 N12 N13 3.40e-07
L13 N12 N13 5.16e-11
R13 N12 N13 3.57e-02
C14 N13 N14 1.21e-11
L14 N13 N14 6.76e-11
R14 N13 N14 7.28e+00
C15 N14 Port2 5.28e-12
L15 N14 Port2 6.92e-11
R15 N14 Port2 1.53e+01
.ENDS GRM21BB31H224KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GRM21BB31H224MA88
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H224MA88 Port1 Port2
C01 Port1 N01 2.26e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.70e-10
R03 N02 N03 8.20e-03
C04 N03 N04 3.10e-05
R04 N03 N04 1.79e+02
C05 N04 N05 2.92e-05
R05 N04 N05 3.41e+01
C06 N05 N06 2.42e-05
R06 N05 N06 3.82e+00
C07 N06 N07 2.76e-05
R07 N06 N07 3.99e-01
C08 N07 N08 2.24e-05
R08 N07 N08 5.48e-02
C09 N08 N09 1.94e-05
R09 N08 N09 1.01e-02
L10 N09 N10 2.41e-11
R10 N09 N10 7.60e-02
L11 N10 N11 1.94e-10
R11 N10 N11 6.32e-02
C12 N11 N12 9.62e-07
L12 N11 N12 3.89e-11
R12 N11 N12 3.26e-02
C13 N12 N13 3.40e-07
L13 N12 N13 5.16e-11
R13 N12 N13 3.57e-02
C14 N13 N14 1.21e-11
L14 N13 N14 6.76e-11
R14 N13 N14 7.28e+00
C15 N14 Port2 5.28e-12
L15 N14 Port2 6.92e-11
R15 N14 Port2 1.53e+01
.ENDS GRM21BB31H224MA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRM21BB31H225KA73
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H225KA73 Port1 Port2
C01 Port1 N01 1.75e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 9.23e-11
R03 N02 N03 6.12e-03
C04 N03 N04 1.55e-05
R04 N03 N04 3.66e+02
C05 N04 N05 4.23e-05
R05 N04 N05 6.79e+00
C06 N05 N06 3.83e-05
R06 N05 N06 7.63e-01
C07 N06 N07 2.95e-05
R07 N06 N07 9.81e-02
C08 N07 N08 2.58e-05
R08 N07 N08 1.11e-02
L09 N08 N09 2.40e-11
R09 N08 N09 3.47e-02
L10 N09 N10 1.48e-10
R10 N09 N10 2.44e-02
C11 N10 N11 5.56e-06
L11 N10 N11 3.52e-11
R11 N10 N11 7.95e-03
C12 N11 N12 1.79e-06
L12 N11 N12 5.26e-11
R12 N11 N12 1.09e-02
C13 N12 N13 1.18e-11
L13 N12 N13 1.11e-10
R13 N12 N13 1.74e+01
C14 N13 Port2 1.92e-12
L14 N13 Port2 1.93e-10
R14 N13 Port2 3.53e+01
.ENDS GRM21BB31H225KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRM21BB31H225MA73
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H225MA73 Port1 Port2
C01 Port1 N01 1.75e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 9.23e-11
R03 N02 N03 6.12e-03
C04 N03 N04 1.55e-05
R04 N03 N04 3.66e+02
C05 N04 N05 4.23e-05
R05 N04 N05 6.79e+00
C06 N05 N06 3.83e-05
R06 N05 N06 7.63e-01
C07 N06 N07 2.95e-05
R07 N06 N07 9.81e-02
C08 N07 N08 2.58e-05
R08 N07 N08 1.11e-02
L09 N08 N09 2.40e-11
R09 N08 N09 3.47e-02
L10 N09 N10 1.48e-10
R10 N09 N10 2.44e-02
C11 N10 N11 5.56e-06
L11 N10 N11 3.52e-11
R11 N10 N11 7.95e-03
C12 N11 N12 1.79e-06
L12 N11 N12 5.26e-11
R12 N11 N12 1.09e-02
C13 N12 N13 1.18e-11
L13 N12 N13 1.11e-10
R13 N12 N13 1.74e+01
C14 N13 Port2 1.92e-12
L14 N13 Port2 1.93e-10
R14 N13 Port2 3.53e+01
.ENDS GRM21BB31H225MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GRM21BB31H474KA87
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H474KA87 Port1 Port2
C01 Port1 N01 4.74e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.57e-10
R03 N02 N03 6.95e-03
C04 N03 N04 6.41e-05
R04 N03 N04 7.09e+01
C05 N04 N05 8.14e-05
R05 N04 N05 1.00e+01
C06 N05 N06 7.17e-05
R06 N05 N06 2.23e+00
C07 N06 N07 5.31e-05
R07 N06 N07 3.16e-01
C08 N07 N08 7.78e-05
R08 N07 N08 3.46e-02
C09 N08 N09 3.75e-05
R09 N08 N09 1.46e-02
C10 N09 N10 1.17e-04
R10 N09 N10 7.75e-04
L11 N10 N11 1.36e-10
R11 N10 N11 4.20e-02
L12 N11 N12 1.25e-11
R12 N11 N12 2.94e-02
C13 N12 N13 1.65e-06
L13 N12 N13 4.45e-11
R13 N12 N13 2.43e-02
C14 N13 N14 5.80e-07
L14 N13 N14 5.43e-11
R14 N13 N14 2.44e-02
C15 N14 N15 1.36e-11
L15 N14 N15 7.11e-11
R15 N14 N15 9.55e+00
C16 N15 Port2 2.23e-12
L16 N15 Port2 1.57e-10
R16 N15 Port2 2.57e+01
.ENDS GRM21BB31H474KA87
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GRM21BB31H474MA87
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H474MA87 Port1 Port2
C01 Port1 N01 4.74e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.57e-10
R03 N02 N03 6.95e-03
C04 N03 N04 6.41e-05
R04 N03 N04 7.09e+01
C05 N04 N05 8.14e-05
R05 N04 N05 1.00e+01
C06 N05 N06 7.17e-05
R06 N05 N06 2.23e+00
C07 N06 N07 5.31e-05
R07 N06 N07 3.16e-01
C08 N07 N08 7.78e-05
R08 N07 N08 3.46e-02
C09 N08 N09 3.75e-05
R09 N08 N09 1.46e-02
C10 N09 N10 1.17e-04
R10 N09 N10 7.75e-04
L11 N10 N11 1.36e-10
R11 N10 N11 4.20e-02
L12 N11 N12 1.25e-11
R12 N11 N12 2.94e-02
C13 N12 N13 1.65e-06
L13 N12 N13 4.45e-11
R13 N12 N13 2.43e-02
C14 N13 N14 5.80e-07
L14 N13 N14 5.43e-11
R14 N13 N14 2.44e-02
C15 N14 N15 1.36e-11
L15 N14 N15 7.11e-11
R15 N14 N15 9.55e+00
C16 N15 Port2 2.23e-12
L16 N15 Port2 1.57e-10
R16 N15 Port2 2.57e+01
.ENDS GRM21BB31H474MA87
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRM21BB31H475KE51
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H475KE51 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.04e-10
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 1.50e-11
L14 N13 N14 5.47e-11
R14 N13 N14 9.30e+00
C15 N14 Port2 1.96e-12
L15 N14 Port2 1.18e-10
R15 N14 Port2 2.13e+01
.ENDS GRM21BB31H475KE51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRM21BB31H475ME51
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H475ME51 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.04e-10
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 1.50e-11
L14 N13 N14 5.47e-11
R14 N13 N14 9.30e+00
C15 N14 Port2 1.96e-12
L15 N14 Port2 1.18e-10
R15 N14 Port2 2.13e+01
.ENDS GRM21BB31H475ME51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/6.80e-01[uF]/50[V]
* Murata P/N :GRM21BB31H684KAC4
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H684KAC4 Port1 Port2
C01 Port1 N01 6.65e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 2.00e-10
R03 N02 N03 5.47e-03
C04 N03 N04 8.86e-05
R04 N03 N04 3.87e+01
C05 N04 N05 1.84e-04
R05 N04 N05 2.87e+00
C06 N05 N06 1.50e-04
R06 N05 N06 5.22e-01
C07 N06 N07 1.68e-04
R07 N06 N07 8.47e-02
C08 N07 N08 9.19e-05
R08 N07 N08 2.13e-02
C09 N08 N09 2.02e-04
R09 N08 N09 1.78e-03
L10 N09 N10 1.50e-10
R10 N09 N10 4.38e-02
L11 N10 N11 1.05e-11
R11 N10 N11 4.01e-02
C12 N11 N12 3.06e-06
L12 N11 N12 3.33e-11
R12 N11 N12 1.15e-02
C13 N12 N13 9.38e-07
L13 N12 N13 5.23e-11
R13 N12 N13 2.18e-02
C14 N13 N14 1.49e-11
L14 N13 N14 1.21e-10
R14 N13 N14 1.23e+01
C15 N14 Port2 4.33e-12
L15 N14 Port2 8.22e-11
R15 N14 Port2 3.64e+01
.ENDS GRM21BB31H684KAC4
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/B(-25to85[deg])/6.80e-01[uF]/50[V]
* Murata P/N :GRM21BB31H684MAC4
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BB31H684MAC4 Port1 Port2
C01 Port1 N01 6.65e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 2.00e-10
R03 N02 N03 5.47e-03
C04 N03 N04 8.86e-05
R04 N03 N04 3.87e+01
C05 N04 N05 1.84e-04
R05 N04 N05 2.87e+00
C06 N05 N06 1.50e-04
R06 N05 N06 5.22e-01
C07 N06 N07 1.68e-04
R07 N06 N07 8.47e-02
C08 N07 N08 9.19e-05
R08 N07 N08 2.13e-02
C09 N08 N09 2.02e-04
R09 N08 N09 1.78e-03
L10 N09 N10 1.50e-10
R10 N09 N10 4.38e-02
L11 N10 N11 1.05e-11
R11 N10 N11 4.01e-02
C12 N11 N12 3.06e-06
L12 N11 N12 3.33e-11
R12 N11 N12 1.15e-02
C13 N12 N13 9.38e-07
L13 N12 N13 5.23e-11
R13 N12 N13 2.18e-02
C14 N13 N14 1.49e-11
L14 N13 N14 1.21e-10
R14 N13 N14 1.23e+01
C15 N14 Port2 4.33e-12
L15 N14 Port2 8.22e-11
R15 N14 Port2 3.64e+01
.ENDS GRM21BB31H684MAC4
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+01[uF]/4[V]
* Murata P/N :GRM21BC70G106KE45
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC70G106KE45 Port1 Port2
C01 Port1 N01 7.29e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.71e-10
R03 N02 N03 2.90e-03
C04 N03 N04 2.17e-04
R04 N03 N04 2.13e+01
C05 N04 N05 2.14e-04
R05 N04 N05 2.19e+00
C06 N05 N06 1.96e-04
R06 N05 N06 2.84e-01
C07 N06 N07 1.70e-04
R07 N06 N07 3.79e-02
C08 N07 N08 1.18e-04
R08 N07 N08 6.36e-03
L09 N08 N09 1.04e-11
R09 N08 N09 8.03e-02
L10 N09 N10 3.83e-11
R10 N09 N10 3.86e-02
L11 N10 N11 3.23e-10
R11 N10 N11 2.11e-02
C12 N11 N12 5.01e-05
L12 N11 N12 2.70e-11
R12 N11 N12 3.41e-03
C13 N12 N13 7.79e-06
L13 N12 N13 9.37e-11
R13 N12 N13 5.71e-03
C14 N13 N14 1.54e-11
L14 N13 N14 3.73e-11
R14 N13 N14 4.45e+00
C15 N14 Port2 1.52e-11
L15 N14 Port2 2.28e-11
R15 N14 Port2 4.37e+00
.ENDS GRM21BC70G106KE45
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM21BC71C106KE11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC71C106KE11 Port1 Port2
C01 Port1 N01 7.48e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.37e-10
R03 N02 N03 2.78e-03
C04 N03 N04 3.44e-04
R04 N03 N04 1.05e+01
C05 N04 N05 5.73e-04
R05 N04 N05 1.17e+00
C06 N05 N06 4.17e-04
R06 N05 N06 2.51e-01
C07 N06 N07 3.55e-04
R07 N06 N07 3.95e-02
C08 N07 N08 2.62e-04
R08 N07 N08 6.48e-03
L09 N08 N09 9.20e-12
R09 N08 N09 4.27e-02
L10 N09 N10 4.13e-11
R10 N09 N10 2.24e-02
L11 N10 N11 2.26e-10
R11 N10 N11 1.42e-02
C12 N11 N12 2.30e-05
L12 N11 N12 6.46e-11
R12 N11 N12 5.50e-03
C13 N12 N13 9.35e-06
L13 N12 N13 7.51e-11
R13 N12 N13 6.55e-03
C14 N13 N14 9.88e-12
L14 N13 N14 7.13e-11
R14 N13 N14 1.50e+01
C15 N14 Port2 2.98e-12
L15 N14 Port2 8.17e-11
R15 N14 Port2 1.99e+01
.ENDS GRM21BC71C106KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM21BC71C106ME11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC71C106ME11 Port1 Port2
C01 Port1 N01 7.48e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.37e-10
R03 N02 N03 2.78e-03
C04 N03 N04 3.44e-04
R04 N03 N04 1.05e+01
C05 N04 N05 5.73e-04
R05 N04 N05 1.17e+00
C06 N05 N06 4.17e-04
R06 N05 N06 2.51e-01
C07 N06 N07 3.55e-04
R07 N06 N07 3.95e-02
C08 N07 N08 2.62e-04
R08 N07 N08 6.48e-03
L09 N08 N09 9.20e-12
R09 N08 N09 4.27e-02
L10 N09 N10 4.13e-11
R10 N09 N10 2.24e-02
L11 N10 N11 2.26e-10
R11 N10 N11 1.42e-02
C12 N11 N12 2.30e-05
L12 N11 N12 6.46e-11
R12 N11 N12 5.50e-03
C13 N12 N13 9.35e-06
L13 N12 N13 7.51e-11
R13 N12 N13 6.55e-03
C14 N13 N14 9.88e-12
L14 N13 N14 7.13e-11
R14 N13 N14 1.50e+01
C15 N14 Port2 2.98e-12
L15 N14 Port2 8.17e-11
R15 N14 Port2 1.99e+01
.ENDS GRM21BC71C106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM21BC71E106KE01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC71E106KE01 Port1 Port2
C01 Port1 N01 7.54e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.78e-10
R03 N02 N03 2.94e-03
C04 N03 N04 2.87e-04
R04 N03 N04 1.72e+01
C05 N04 N05 4.14e-04
R05 N04 N05 1.65e+00
C06 N05 N06 4.15e-04
R06 N05 N06 3.01e-01
C07 N06 N07 4.24e-04
R07 N06 N07 5.32e-02
C08 N07 N08 3.28e-04
R08 N07 N08 1.35e-02
C09 N08 N09 2.93e-04
R09 N08 N09 2.54e-03
L10 N09 N10 1.41e-11
R10 N09 N10 6.56e-02
L11 N10 N11 3.18e-11
R11 N10 N11 1.77e-02
L12 N11 N12 3.16e-10
R12 N11 N12 1.64e-02
C13 N12 N13 1.82e-05
L13 N12 N13 8.18e-11
R13 N12 N13 6.92e-03
C14 N13 N14 1.33e-05
L14 N13 N14 5.46e-11
R14 N13 N14 6.00e-03
C15 N14 Port2 4.91e-12
L15 N14 Port2 8.11e-11
R15 N14 Port2 1.90e+01
.ENDS GRM21BC71E106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM21BC71E106KE11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC71E106KE11 Port1 Port2
C01 Port1 N01 7.48e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.37e-10
R03 N02 N03 2.78e-03
C04 N03 N04 3.44e-04
R04 N03 N04 1.05e+01
C05 N04 N05 5.73e-04
R05 N04 N05 1.17e+00
C06 N05 N06 4.17e-04
R06 N05 N06 2.51e-01
C07 N06 N07 3.55e-04
R07 N06 N07 3.95e-02
C08 N07 N08 2.62e-04
R08 N07 N08 6.48e-03
L09 N08 N09 9.20e-12
R09 N08 N09 4.27e-02
L10 N09 N10 4.13e-11
R10 N09 N10 2.24e-02
L11 N10 N11 2.26e-10
R11 N10 N11 1.42e-02
C12 N11 N12 2.30e-05
L12 N11 N12 6.46e-11
R12 N11 N12 5.50e-03
C13 N12 N13 9.35e-06
L13 N12 N13 7.51e-11
R13 N12 N13 6.55e-03
C14 N13 N14 9.88e-12
L14 N13 N14 7.13e-11
R14 N13 N14 1.50e+01
C15 N14 Port2 2.98e-12
L15 N14 Port2 8.17e-11
R15 N14 Port2 1.99e+01
.ENDS GRM21BC71E106KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM21BC71E106ME01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC71E106ME01 Port1 Port2
C01 Port1 N01 6.77e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.02e-10
R03 N02 N03 3.12e-03
C04 N03 N04 2.56e-04
R04 N03 N04 2.08e+01
C05 N04 N05 3.69e-04
R05 N04 N05 2.00e+00
C06 N05 N06 3.33e-04
R06 N05 N06 3.51e-01
C07 N06 N07 3.21e-04
R07 N06 N07 5.38e-02
C08 N07 N08 3.96e-04
R08 N07 N08 8.34e-03
C09 N08 N09 3.24e-04
R09 N08 N09 3.37e-03
L10 N09 N10 1.17e-11
R10 N09 N10 5.17e-02
L11 N10 N11 3.15e-11
R11 N10 N11 1.84e-02
L12 N11 N12 2.83e-10
R12 N11 N12 1.56e-02
C13 N12 N13 2.19e-05
L13 N12 N13 5.97e-11
R13 N12 N13 6.18e-03
C14 N13 N14 9.00e-06
L14 N13 N14 7.04e-11
R14 N13 N14 6.48e-03
C15 N14 Port2 5.04e-12
L15 N14 Port2 1.03e-10
R15 N14 Port2 2.19e+01
.ENDS GRM21BC71E106ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM21BC71E106ME11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC71E106ME11 Port1 Port2
C01 Port1 N01 7.48e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.37e-10
R03 N02 N03 2.78e-03
C04 N03 N04 3.44e-04
R04 N03 N04 1.05e+01
C05 N04 N05 5.73e-04
R05 N04 N05 1.17e+00
C06 N05 N06 4.17e-04
R06 N05 N06 2.51e-01
C07 N06 N07 3.55e-04
R07 N06 N07 3.95e-02
C08 N07 N08 2.62e-04
R08 N07 N08 6.48e-03
L09 N08 N09 9.20e-12
R09 N08 N09 4.27e-02
L10 N09 N10 4.13e-11
R10 N09 N10 2.24e-02
L11 N10 N11 2.26e-10
R11 N10 N11 1.42e-02
C12 N11 N12 2.30e-05
L12 N11 N12 6.46e-11
R12 N11 N12 5.50e-03
C13 N12 N13 9.35e-06
L13 N12 N13 7.51e-11
R13 N12 N13 6.55e-03
C14 N13 N14 9.88e-12
L14 N13 N14 7.13e-11
R14 N13 N14 1.50e+01
C15 N14 Port2 2.98e-12
L15 N14 Port2 8.17e-11
R15 N14 Port2 1.99e+01
.ENDS GRM21BC71E106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM21BC71E225KE11
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC71E225KE11 Port1 Port2
C01 Port1 N01 1.54e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 6.96e-11
R03 N02 N03 5.31e-03
C04 N03 N04 5.73e-05
R04 N03 N04 1.89e+01
C05 N04 N05 6.18e-05
R05 N04 N05 1.89e+00
C06 N05 N06 5.69e-05
R06 N05 N06 2.43e-01
C07 N06 N07 4.83e-05
R07 N06 N07 4.09e-02
C08 N07 N08 3.71e-05
R08 N07 N08 8.90e-03
L09 N08 N09 2.15e-11
R09 N08 N09 8.28e-02
L10 N09 N10 1.76e-10
R10 N09 N10 3.78e-02
C11 N10 N11 4.17e-06
L11 N10 N11 5.62e-11
R11 N10 N11 1.39e-02
C12 N11 N12 1.59e-06
L12 N11 N12 6.69e-11
R12 N11 N12 1.58e-02
C13 N12 N13 1.49e-11
L13 N12 N13 5.47e-11
R13 N12 N13 9.57e+00
C14 N13 Port2 1.66e-12
L14 N13 Port2 1.38e-10
R14 N13 Port2 2.51e+01
.ENDS GRM21BC71E225KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM21BC71E225ME11
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC71E225ME11 Port1 Port2
C01 Port1 N01 1.54e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 6.96e-11
R03 N02 N03 5.31e-03
C04 N03 N04 5.73e-05
R04 N03 N04 1.89e+01
C05 N04 N05 6.18e-05
R05 N04 N05 1.89e+00
C06 N05 N06 5.69e-05
R06 N05 N06 2.43e-01
C07 N06 N07 4.83e-05
R07 N06 N07 4.09e-02
C08 N07 N08 3.71e-05
R08 N07 N08 8.90e-03
L09 N08 N09 2.15e-11
R09 N08 N09 8.28e-02
L10 N09 N10 1.76e-10
R10 N09 N10 3.78e-02
C11 N10 N11 4.17e-06
L11 N10 N11 5.62e-11
R11 N10 N11 1.39e-02
C12 N11 N12 1.59e-06
L12 N11 N12 6.69e-11
R12 N11 N12 1.58e-02
C13 N12 N13 1.49e-11
L13 N12 N13 5.47e-11
R13 N12 N13 9.57e+00
C14 N13 Port2 1.66e-12
L14 N13 Port2 1.38e-10
R14 N13 Port2 2.51e+01
.ENDS GRM21BC71E225ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRM21BC71E475KE11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC71E475KE11 Port1 Port2
C01 Port1 N01 3.70e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.53e-10
R03 N02 N03 3.75e-03
C04 N03 N04 1.00e-04
R04 N03 N04 5.31e+01
C05 N04 N05 1.94e-04
R05 N04 N05 2.51e+00
C06 N05 N06 1.82e-04
R06 N05 N06 3.42e-01
C07 N06 N07 1.54e-04
R07 N06 N07 4.68e-02
C08 N07 N08 1.30e-04
R08 N07 N08 7.94e-03
C09 N08 N09 3.67e-04
R09 N08 N09 8.93e-04
L10 N09 N10 9.63e-12
R10 N09 N10 6.12e-02
L11 N10 N11 2.62e-11
R11 N10 N11 3.33e-02
L12 N11 N12 2.36e-10
R12 N11 N12 2.38e-02
C13 N12 N13 8.25e-06
L13 N12 N13 7.75e-11
R13 N12 N13 1.13e-02
C14 N13 N14 5.12e-06
L14 N13 N14 5.89e-11
R14 N13 N14 9.57e-03
C15 N14 N15 1.75e-11
L15 N14 N15 3.17e-11
R15 N14 N15 7.89e+00
C16 N15 Port2 5.92e-12
L16 N15 Port2 5.84e-11
R16 N15 Port2 1.71e+01
.ENDS GRM21BC71E475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRM21BC71E475ME11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC71E475ME11 Port1 Port2
C01 Port1 N01 3.70e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.53e-10
R03 N02 N03 3.75e-03
C04 N03 N04 1.00e-04
R04 N03 N04 5.31e+01
C05 N04 N05 1.94e-04
R05 N04 N05 2.51e+00
C06 N05 N06 1.82e-04
R06 N05 N06 3.42e-01
C07 N06 N07 1.54e-04
R07 N06 N07 4.68e-02
C08 N07 N08 1.30e-04
R08 N07 N08 7.94e-03
C09 N08 N09 3.67e-04
R09 N08 N09 8.93e-04
L10 N09 N10 9.63e-12
R10 N09 N10 6.12e-02
L11 N10 N11 2.62e-11
R11 N10 N11 3.33e-02
L12 N11 N12 2.36e-10
R12 N11 N12 2.38e-02
C13 N12 N13 8.25e-06
L13 N12 N13 7.75e-11
R13 N12 N13 1.13e-02
C14 N13 N14 5.12e-06
L14 N13 N14 5.89e-11
R14 N13 N14 9.57e-03
C15 N14 N15 1.75e-11
L15 N14 N15 3.17e-11
R15 N14 N15 7.89e+00
C16 N15 Port2 5.92e-12
L16 N15 Port2 5.84e-11
R16 N15 Port2 1.71e+01
.ENDS GRM21BC71E475ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRM21BC71H475KE11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC71H475KE11 Port1 Port2
C01 Port1 N01 3.70e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.53e-10
R03 N02 N03 3.75e-03
C04 N03 N04 1.00e-04
R04 N03 N04 5.31e+01
C05 N04 N05 1.94e-04
R05 N04 N05 2.51e+00
C06 N05 N06 1.82e-04
R06 N05 N06 3.42e-01
C07 N06 N07 1.54e-04
R07 N06 N07 4.68e-02
C08 N07 N08 1.30e-04
R08 N07 N08 7.94e-03
C09 N08 N09 3.67e-04
R09 N08 N09 8.93e-04
L10 N09 N10 9.63e-12
R10 N09 N10 6.12e-02
L11 N10 N11 2.62e-11
R11 N10 N11 3.33e-02
L12 N11 N12 2.36e-10
R12 N11 N12 2.38e-02
C13 N12 N13 8.25e-06
L13 N12 N13 7.75e-11
R13 N12 N13 1.13e-02
C14 N13 N14 5.12e-06
L14 N13 N14 5.89e-11
R14 N13 N14 9.57e-03
C15 N14 N15 1.75e-11
L15 N14 N15 3.17e-11
R15 N14 N15 7.89e+00
C16 N15 Port2 5.92e-12
L16 N15 Port2 5.84e-11
R16 N15 Port2 1.71e+01
.ENDS GRM21BC71H475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRM21BC71H475ME11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC71H475ME11 Port1 Port2
C01 Port1 N01 3.70e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.53e-10
R03 N02 N03 3.75e-03
C04 N03 N04 1.00e-04
R04 N03 N04 5.31e+01
C05 N04 N05 1.94e-04
R05 N04 N05 2.51e+00
C06 N05 N06 1.82e-04
R06 N05 N06 3.42e-01
C07 N06 N07 1.54e-04
R07 N06 N07 4.68e-02
C08 N07 N08 1.30e-04
R08 N07 N08 7.94e-03
C09 N08 N09 3.67e-04
R09 N08 N09 8.93e-04
L10 N09 N10 9.63e-12
R10 N09 N10 6.12e-02
L11 N10 N11 2.62e-11
R11 N10 N11 3.33e-02
L12 N11 N12 2.36e-10
R12 N11 N12 2.38e-02
C13 N12 N13 8.25e-06
L13 N12 N13 7.75e-11
R13 N12 N13 1.13e-02
C14 N13 N14 5.12e-06
L14 N13 N14 5.89e-11
R14 N13 N14 9.57e-03
C15 N14 N15 1.75e-11
L15 N14 N15 3.17e-11
R15 N14 N15 7.89e+00
C16 N15 Port2 5.92e-12
L16 N15 Port2 5.84e-11
R16 N15 Port2 1.71e+01
.ENDS GRM21BC71H475ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GRM21BC72A105KE01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC72A105KE01 Port1 Port2
C01 Port1 N01 9.82e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.66e-10
R03 N02 N03 5.53e-03
C04 N03 N04 1.26e-04
R04 N03 N04 1.83e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.42e+00
C06 N05 N06 9.29e-05
R06 N05 N06 6.37e-01
C07 N06 N07 1.02e-04
R07 N06 N07 8.81e-02
C08 N07 N08 7.34e-05
R08 N07 N08 1.78e-02
C09 N08 N09 8.17e-05
R09 N08 N09 2.84e-03
L10 N09 N10 1.43e-11
R10 N09 N10 5.47e-02
L11 N10 N11 2.26e-10
R11 N10 N11 3.59e-02
L12 N11 N12 1.77e-11
R12 N11 N12 2.03e-02
C13 N12 N13 3.02e-06
L13 N12 N13 5.59e-11
R13 N12 N13 1.53e-02
C14 N13 N14 1.62e-06
L14 N13 N14 4.80e-11
R14 N13 N14 1.33e-02
C15 N14 N15 1.20e-11
L15 N14 N15 8.39e-11
R15 N14 N15 6.83e+00
C16 N15 Port2 7.24e-12
L16 N15 Port2 4.44e-11
R16 N15 Port2 1.30e+01
.ENDS GRM21BC72A105KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GRM21BC7YA475KE11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC7YA475KE11 Port1 Port2
C01 Port1 N01 3.70e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.53e-10
R03 N02 N03 3.75e-03
C04 N03 N04 1.00e-04
R04 N03 N04 5.31e+01
C05 N04 N05 1.94e-04
R05 N04 N05 2.51e+00
C06 N05 N06 1.82e-04
R06 N05 N06 3.42e-01
C07 N06 N07 1.54e-04
R07 N06 N07 4.68e-02
C08 N07 N08 1.30e-04
R08 N07 N08 7.94e-03
C09 N08 N09 3.67e-04
R09 N08 N09 8.93e-04
L10 N09 N10 9.63e-12
R10 N09 N10 6.12e-02
L11 N10 N11 2.62e-11
R11 N10 N11 3.33e-02
L12 N11 N12 2.36e-10
R12 N11 N12 2.38e-02
C13 N12 N13 8.25e-06
L13 N12 N13 7.75e-11
R13 N12 N13 1.13e-02
C14 N13 N14 5.12e-06
L14 N13 N14 5.89e-11
R14 N13 N14 9.57e-03
C15 N14 N15 1.75e-11
L15 N14 N15 3.17e-11
R15 N14 N15 7.89e+00
C16 N15 Port2 5.92e-12
L16 N15 Port2 5.84e-11
R16 N15 Port2 1.71e+01
.ENDS GRM21BC7YA475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GRM21BC7YA475ME11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC7YA475ME11 Port1 Port2
C01 Port1 N01 3.70e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.53e-10
R03 N02 N03 3.75e-03
C04 N03 N04 1.00e-04
R04 N03 N04 5.31e+01
C05 N04 N05 1.94e-04
R05 N04 N05 2.51e+00
C06 N05 N06 1.82e-04
R06 N05 N06 3.42e-01
C07 N06 N07 1.54e-04
R07 N06 N07 4.68e-02
C08 N07 N08 1.30e-04
R08 N07 N08 7.94e-03
C09 N08 N09 3.67e-04
R09 N08 N09 8.93e-04
L10 N09 N10 9.63e-12
R10 N09 N10 6.12e-02
L11 N10 N11 2.62e-11
R11 N10 N11 3.33e-02
L12 N11 N12 2.36e-10
R12 N11 N12 2.38e-02
C13 N12 N13 8.25e-06
L13 N12 N13 7.75e-11
R13 N12 N13 1.13e-02
C14 N13 N14 5.12e-06
L14 N13 N14 5.89e-11
R14 N13 N14 9.57e-03
C15 N14 N15 1.75e-11
L15 N14 N15 3.17e-11
R15 N14 N15 7.89e+00
C16 N15 Port2 5.92e-12
L16 N15 Port2 5.84e-11
R16 N15 Port2 1.71e+01
.ENDS GRM21BC7YA475ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+02[uF]/2.5[V]
* Murata P/N :GRM21BC80E107ME15
* Property : C = 1.00e+02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC80E107ME15 Port1 Port2
C01 Port1 N01 7.31e-05
R01 Port1 N01 5.00e+05
L02 N01 N02 1.95e-10
R03 N02 N03 1.33e-03
C04 N03 N04 4.16e-03
R04 N03 N04 8.33e-01
C05 N04 N05 5.06e-03
R05 N04 N05 6.43e-02
C06 N05 N06 4.91e-03
R06 N05 N06 1.09e-02
C07 N06 N07 8.50e-03
R07 N06 N07 5.04e-04
L08 N07 N08 1.53e-11
R08 N07 N08 6.08e-02
L09 N08 N09 2.67e-11
R09 N08 N09 2.12e-02
L10 N09 N10 7.82e-11
R10 N09 N10 1.23e-02
L11 N10 N11 4.17e-10
R11 N10 N11 6.65e-03
C12 N11 N12 1.73e-04
L12 N11 N12 1.28e-10
R12 N11 N12 1.08e-03
C13 N12 N13 1.53e-04
L13 N12 N13 8.20e-11
R13 N12 N13 8.47e-04
C14 N13 Port2 3.16e-11
L14 N13 Port2 4.12e-11
R14 N13 Port2 2.24e+00
.ENDS GRM21BC80E107ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/4[V]
* Murata P/N :GRM21BC80G106KE01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC80G106KE01 Port1 Port2
C01 Port1 N01 9.18e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.26e-10
R03 N02 N03 2.16e-03
C04 N03 N04 1.04e-03
R04 N03 N04 2.98e+00
C05 N04 N05 1.49e-03
R05 N04 N05 3.42e-01
C06 N05 N06 1.27e-03
R06 N05 N06 7.91e-02
C07 N06 N07 1.85e-03
R07 N06 N07 8.69e-03
C08 N07 N08 1.53e-03
R08 N07 N08 1.94e-03
L09 N08 N09 2.52e-11
R09 N08 N09 4.09e-02
L10 N09 N10 5.61e-11
R10 N09 N10 1.55e-02
L11 N10 N11 3.50e-10
R11 N10 N11 1.29e-02
C12 N11 N12 5.29e-05
L12 N11 N12 4.36e-11
R12 N11 N12 2.51e-03
C13 N12 N13 2.02e-05
L13 N12 N13 6.14e-11
R13 N12 N13 3.68e-03
C14 N13 N14 2.07e-11
L14 N13 N14 5.98e-11
R14 N13 N14 4.34e+00
C15 N14 Port2 2.32e-12
L15 N14 Port2 8.59e-11
R15 N14 Port2 2.19e+01
.ENDS GRM21BC80G106KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/4[V]
* Murata P/N :GRM21BC80G106ME19
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC80G106ME19 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BC80G106ME19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+02[uF]/4[V]
* Murata P/N :GRM21BC80G107ME15
* Property : C = 1.00e+02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC80G107ME15 Port1 Port2
C01 Port1 N01 7.31e-05
R01 Port1 N01 5.00e+05
L02 N01 N02 1.95e-10
R03 N02 N03 1.33e-03
C04 N03 N04 4.16e-03
R04 N03 N04 8.33e-01
C05 N04 N05 5.06e-03
R05 N04 N05 6.43e-02
C06 N05 N06 4.91e-03
R06 N05 N06 1.09e-02
C07 N06 N07 8.50e-03
R07 N06 N07 5.04e-04
L08 N07 N08 1.53e-11
R08 N07 N08 6.08e-02
L09 N08 N09 2.67e-11
R09 N08 N09 2.12e-02
L10 N09 N10 7.82e-11
R10 N09 N10 1.23e-02
L11 N10 N11 4.17e-10
R11 N10 N11 6.65e-03
C12 N11 N12 1.73e-04
L12 N11 N12 1.28e-10
R12 N11 N12 1.08e-03
C13 N12 N13 1.53e-04
L13 N12 N13 8.20e-11
R13 N12 N13 8.47e-04
C14 N13 Port2 3.16e-11
L14 N13 Port2 4.12e-11
R14 N13 Port2 2.24e+00
.ENDS GRM21BC80G107ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+01[uF]/4[V]
* Murata P/N :GRM21BC80G226ME39
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC80G226ME39 Port1 Port2
C01 Port1 N01 1.41e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.44e-10
R03 N02 N03 2.43e-03
C04 N03 N04 2.83e-04
R04 N03 N04 2.01e+01
C05 N04 N05 3.85e-04
R05 N04 N05 1.39e+00
C06 N05 N06 3.52e-04
R06 N05 N06 1.52e-01
C07 N06 N07 2.64e-04
R07 N06 N07 1.93e-02
C08 N07 N08 3.46e-04
R08 N07 N08 1.96e-03
L09 N08 N09 1.53e-11
R09 N08 N09 8.38e-02
L10 N09 N10 4.59e-11
R10 N09 N10 2.50e-02
L11 N10 N11 3.75e-10
R11 N10 N11 1.39e-02
C12 N11 N12 3.43e-05
L12 N11 N12 7.23e-11
R12 N11 N12 3.39e-03
C13 N12 N13 7.50e-05
L13 N12 N13 1.79e-11
R13 N12 N13 2.21e-03
C14 N13 N14 1.45e-11
L14 N13 N14 5.81e-11
R14 N13 N14 7.85e+00
C15 N14 Port2 8.35e-12
L15 N14 Port2 3.97e-11
R15 N14 Port2 5.40e+00
.ENDS GRM21BC80G226ME39
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+01[uF]/4[V]
* Murata P/N :GRM21BC80G476ME15
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC80G476ME15 Port1 Port2
C01 Port1 N01 3.55e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 9.05e-11
R03 N02 N03 1.62e-03
C04 N03 N04 1.31e-03
R04 N03 N04 4.05e+00
C05 N04 N05 1.75e-03
R05 N04 N05 3.57e-01
C06 N05 N06 2.34e-03
R06 N05 N06 2.90e-02
C07 N06 N07 2.97e-03
R07 N06 N07 2.18e-03
L08 N07 N08 1.39e-11
R08 N07 N08 6.34e-02
L09 N08 N09 6.62e-11
R09 N08 N09 2.53e-02
L10 N09 N10 3.97e-10
R10 N09 N10 9.41e-03
C11 N10 N11 3.11e-05
L11 N10 N11 2.18e-10
R11 N10 N11 2.51e-03
C12 N11 N12 2.00e-11
L12 N11 N12 5.83e-11
R12 N11 N12 6.42e+00
C13 N12 Port2 2.17e-12
L13 N12 Port2 1.22e-10
R13 N12 Port2 2.59e+01
.ENDS GRM21BC80G476ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM21BC80J106KE19
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC80J106KE19 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BC80J106KE19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM21BC80J106ME19
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC80J106ME19 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BC80J106ME19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRM21BC80J226ME51
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC80J226ME51 Port1 Port2
C01 Port1 N01 1.41e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.44e-10
R03 N02 N03 2.43e-03
C04 N03 N04 2.83e-04
R04 N03 N04 2.01e+01
C05 N04 N05 3.85e-04
R05 N04 N05 1.39e+00
C06 N05 N06 3.52e-04
R06 N05 N06 1.52e-01
C07 N06 N07 2.64e-04
R07 N06 N07 1.93e-02
C08 N07 N08 3.46e-04
R08 N07 N08 1.96e-03
L09 N08 N09 1.53e-11
R09 N08 N09 8.38e-02
L10 N09 N10 4.59e-11
R10 N09 N10 2.50e-02
L11 N10 N11 3.75e-10
R11 N10 N11 1.39e-02
C12 N11 N12 3.43e-05
L12 N11 N12 7.23e-11
R12 N11 N12 3.39e-03
C13 N12 N13 7.50e-05
L13 N12 N13 1.79e-11
R13 N12 N13 2.21e-03
C14 N13 N14 1.45e-11
L14 N13 N14 5.81e-11
R14 N13 N14 7.85e+00
C15 N14 Port2 8.35e-12
L15 N14 Port2 3.97e-11
R15 N14 Port2 5.40e+00
.ENDS GRM21BC80J226ME51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRM21BC80J476ME01
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC80J476ME01 Port1 Port2
C01 Port1 N01 3.52e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 2.05e-10
R03 N02 N03 1.67e-03
C04 N03 N04 2.28e-03
R04 N03 N04 2.17e+00
C05 N04 N05 2.84e-03
R05 N04 N05 2.60e-01
C06 N05 N06 2.15e-03
R06 N05 N06 4.94e-02
C07 N06 N07 3.03e-03
R07 N06 N07 4.57e-03
C08 N07 N08 3.25e-03
R08 N07 N08 7.62e-04
L09 N08 N09 2.45e-11
R09 N08 N09 4.67e-02
L10 N09 N10 6.10e-11
R10 N09 N10 1.47e-02
L11 N10 N11 4.02e-10
R11 N10 N11 8.76e-03
C12 N11 N12 1.61e-04
L12 N11 N12 6.19e-11
R12 N11 N12 1.45e-03
C13 N12 N13 5.85e-05
L13 N12 N13 8.49e-11
R13 N12 N13 1.97e-03
C14 N13 N14 3.07e-11
L14 N13 N14 4.27e-11
R14 N13 N14 3.61e+00
C15 N14 Port2 1.16e-11
L15 N14 Port2 2.87e-11
R15 N14 Port2 5.32e+00
.ENDS GRM21BC80J476ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM21BC81A106KE18
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81A106KE18 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BC81A106KE18
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM21BC81A106ME18
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81A106ME18 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BC81A106ME18
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRM21BC81A226ME44
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81A226ME44 Port1 Port2
C01 Port1 N01 1.70e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.60e-10
R03 N02 N03 2.11e-03
C04 N03 N04 6.67e-04
R04 N03 N04 7.95e+00
C05 N04 N05 7.65e-04
R05 N04 N05 7.74e-01
C06 N05 N06 7.03e-04
R06 N05 N06 9.99e-02
C07 N06 N07 6.45e-04
R07 N06 N07 1.24e-02
C08 N07 N08 6.19e-04
R08 N07 N08 1.97e-03
L09 N08 N09 1.62e-11
R09 N08 N09 5.44e-02
L10 N09 N10 3.66e-11
R10 N09 N10 2.02e-02
L11 N10 N11 3.37e-10
R11 N10 N11 1.34e-02
C12 N11 N12 5.83e-05
L12 N11 N12 6.41e-11
R12 N11 N12 3.35e-03
C13 N12 N13 2.26e-05
L13 N12 N13 8.31e-11
R13 N12 N13 3.61e-03
C14 N13 Port2 4.77e-12
L14 N13 Port2 8.46e-11
R14 N13 Port2 1.47e+01
.ENDS GRM21BC81A226ME44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM21BC81C106KA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81C106KA73 Port1 Port2
C01 Port1 N01 6.20e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.12e-10
R03 N02 N03 3.36e-03
C04 N03 N04 1.83e-04
R04 N03 N04 1.39e+01
C05 N04 N05 2.37e-04
R05 N04 N05 1.12e+00
C06 N05 N06 2.37e-04
R06 N05 N06 1.49e-01
C07 N06 N07 2.04e-04
R07 N06 N07 2.32e-02
C08 N07 N08 1.99e-04
R08 N07 N08 4.48e-03
L09 N08 N09 1.70e-11
R09 N08 N09 1.04e-01
L10 N09 N10 3.26e-11
R10 N09 N10 2.48e-02
L11 N10 N11 2.49e-10
R11 N10 N11 1.86e-02
C12 N11 N12 1.84e-05
L12 N11 N12 6.20e-11
R12 N11 N12 4.79e-03
C13 N12 N13 1.22e-05
L13 N12 N13 4.65e-11
R13 N12 N13 3.76e-03
C14 N13 Port2 8.91e-12
L14 N13 Port2 7.96e-11
R14 N13 Port2 1.34e+01
.ENDS GRM21BC81C106KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM21BC81C106KE15
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81C106KE15 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BC81C106KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM21BC81C106MA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81C106MA73 Port1 Port2
C01 Port1 N01 6.20e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.12e-10
R03 N02 N03 3.36e-03
C04 N03 N04 1.83e-04
R04 N03 N04 1.39e+01
C05 N04 N05 2.37e-04
R05 N04 N05 1.12e+00
C06 N05 N06 2.37e-04
R06 N05 N06 1.49e-01
C07 N06 N07 2.04e-04
R07 N06 N07 2.32e-02
C08 N07 N08 1.99e-04
R08 N07 N08 4.48e-03
L09 N08 N09 1.70e-11
R09 N08 N09 1.04e-01
L10 N09 N10 3.26e-11
R10 N09 N10 2.48e-02
L11 N10 N11 2.49e-10
R11 N10 N11 1.86e-02
C12 N11 N12 1.84e-05
L12 N11 N12 6.20e-11
R12 N11 N12 4.79e-03
C13 N12 N13 1.22e-05
L13 N12 N13 4.65e-11
R13 N12 N13 3.76e-03
C14 N13 Port2 8.91e-12
L14 N13 Port2 7.96e-11
R14 N13 Port2 1.34e+01
.ENDS GRM21BC81C106MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM21BC81C106ME15
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81C106ME15 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BC81C106ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GRM21BC81C226ME44
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81C226ME44 Port1 Port2
C01 Port1 N01 1.70e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.60e-10
R03 N02 N03 2.11e-03
C04 N03 N04 6.67e-04
R04 N03 N04 7.95e+00
C05 N04 N05 7.65e-04
R05 N04 N05 7.74e-01
C06 N05 N06 7.03e-04
R06 N05 N06 9.99e-02
C07 N06 N07 6.45e-04
R07 N06 N07 1.24e-02
C08 N07 N08 6.19e-04
R08 N07 N08 1.97e-03
L09 N08 N09 1.62e-11
R09 N08 N09 5.44e-02
L10 N09 N10 3.66e-11
R10 N09 N10 2.02e-02
L11 N10 N11 3.37e-10
R11 N10 N11 1.34e-02
C12 N11 N12 5.83e-05
L12 N11 N12 6.41e-11
R12 N11 N12 3.35e-03
C13 N12 N13 2.26e-05
L13 N12 N13 8.31e-11
R13 N12 N13 3.61e-03
C14 N13 Port2 4.77e-12
L14 N13 Port2 8.46e-11
R14 N13 Port2 1.47e+01
.ENDS GRM21BC81C226ME44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM21BC81C475KA88
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81C475KA88 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRM21BC81C475KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM21BC81E106KE51
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81E106KE51 Port1 Port2
C01 Port1 N01 6.04e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.09e-10
R03 N02 N03 3.59e-03
C04 N03 N04 1.76e-04
R04 N03 N04 8.12e+00
C05 N04 N05 2.23e-04
R05 N04 N05 8.35e-01
C06 N05 N06 2.19e-04
R06 N05 N06 1.26e-01
C07 N06 N07 2.18e-04
R07 N06 N07 2.25e-02
C08 N07 N08 1.42e-04
R08 N07 N08 6.25e-03
L09 N08 N09 2.51e-11
R09 N08 N09 1.01e-01
L10 N09 N10 2.94e-11
R10 N09 N10 2.08e-02
L11 N10 N11 2.06e-10
R11 N10 N11 1.93e-02
C12 N11 N12 1.81e-05
L12 N11 N12 5.96e-11
R12 N11 N12 4.84e-03
C13 N12 N13 5.67e-06
L13 N12 N13 8.85e-11
R13 N12 N13 7.11e-03
C14 N13 N14 2.22e-11
L14 N13 N14 4.37e-11
R14 N13 N14 4.84e+00
C15 N14 Port2 1.75e-11
L15 N14 Port2 1.65e-11
R15 N14 Port2 5.30e+00
.ENDS GRM21BC81E106KE51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM21BC81E106ME51
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81E106ME51 Port1 Port2
C01 Port1 N01 6.04e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.09e-10
R03 N02 N03 3.59e-03
C04 N03 N04 1.76e-04
R04 N03 N04 8.12e+00
C05 N04 N05 2.23e-04
R05 N04 N05 8.35e-01
C06 N05 N06 2.19e-04
R06 N05 N06 1.26e-01
C07 N06 N07 2.18e-04
R07 N06 N07 2.25e-02
C08 N07 N08 1.42e-04
R08 N07 N08 6.25e-03
L09 N08 N09 2.51e-11
R09 N08 N09 1.01e-01
L10 N09 N10 2.94e-11
R10 N09 N10 2.08e-02
L11 N10 N11 2.06e-10
R11 N10 N11 1.93e-02
C12 N11 N12 1.81e-05
L12 N11 N12 5.96e-11
R12 N11 N12 4.84e-03
C13 N12 N13 5.67e-06
L13 N12 N13 8.85e-11
R13 N12 N13 7.11e-03
C14 N13 N14 2.22e-11
L14 N13 N14 4.37e-11
R14 N13 N14 4.84e+00
C15 N14 Port2 1.75e-11
L15 N14 Port2 1.65e-11
R15 N14 Port2 5.30e+00
.ENDS GRM21BC81E106ME51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM21BC81E225KA12
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81E225KA12 Port1 Port2
C01 Port1 N01 1.65e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 7.14e-11
R03 N02 N03 5.67e-03
C04 N03 N04 2.63e-05
R04 N03 N04 2.01e+02
C05 N04 N05 4.26e-05
R05 N04 N05 7.12e+00
C06 N05 N06 3.99e-05
R06 N05 N06 6.91e-01
C07 N06 N07 3.03e-05
R07 N06 N07 9.36e-02
C08 N07 N08 2.45e-05
R08 N07 N08 1.11e-02
L09 N08 N09 1.74e-11
R09 N08 N09 2.85e-02
L10 N09 N10 1.81e-10
R10 N09 N10 2.66e-02
C11 N10 N11 6.55e-06
L11 N10 N11 2.93e-11
R11 N10 N11 7.55e-03
C12 N11 N12 2.70e-06
L12 N11 N12 3.14e-11
R12 N11 N12 1.00e-02
C13 N12 N13 7.79e-12
L13 N12 N13 1.48e-10
R13 N12 N13 2.12e+01
C14 N13 Port2 2.08e-12
L14 N13 Port2 1.84e-10
R14 N13 Port2 3.72e+01
.ENDS GRM21BC81E225KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRM21BC81E475KA12
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81E475KA12 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRM21BC81E475KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRM21BC81E475MA12
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81E475MA12 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRM21BC81E475MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRM21BC81H475KE11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81H475KE11 Port1 Port2
C01 Port1 N01 3.70e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.53e-10
R03 N02 N03 3.75e-03
C04 N03 N04 1.00e-04
R04 N03 N04 5.31e+01
C05 N04 N05 1.94e-04
R05 N04 N05 2.51e+00
C06 N05 N06 1.82e-04
R06 N05 N06 3.42e-01
C07 N06 N07 1.54e-04
R07 N06 N07 4.68e-02
C08 N07 N08 1.30e-04
R08 N07 N08 7.94e-03
C09 N08 N09 3.67e-04
R09 N08 N09 8.93e-04
L10 N09 N10 9.63e-12
R10 N09 N10 6.12e-02
L11 N10 N11 2.62e-11
R11 N10 N11 3.33e-02
L12 N11 N12 2.36e-10
R12 N11 N12 2.38e-02
C13 N12 N13 8.25e-06
L13 N12 N13 7.75e-11
R13 N12 N13 1.13e-02
C14 N13 N14 5.12e-06
L14 N13 N14 5.89e-11
R14 N13 N14 9.57e-03
C15 N14 N15 1.75e-11
L15 N14 N15 3.17e-11
R15 N14 N15 7.89e+00
C16 N15 Port2 5.92e-12
L16 N15 Port2 5.84e-11
R16 N15 Port2 1.71e+01
.ENDS GRM21BC81H475KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRM21BC81H475ME11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC81H475ME11 Port1 Port2
C01 Port1 N01 3.70e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.53e-10
R03 N02 N03 3.75e-03
C04 N03 N04 1.00e-04
R04 N03 N04 5.31e+01
C05 N04 N05 1.94e-04
R05 N04 N05 2.51e+00
C06 N05 N06 1.82e-04
R06 N05 N06 3.42e-01
C07 N06 N07 1.54e-04
R07 N06 N07 4.68e-02
C08 N07 N08 1.30e-04
R08 N07 N08 7.94e-03
C09 N08 N09 3.67e-04
R09 N08 N09 8.93e-04
L10 N09 N10 9.63e-12
R10 N09 N10 6.12e-02
L11 N10 N11 2.62e-11
R11 N10 N11 3.33e-02
L12 N11 N12 2.36e-10
R12 N11 N12 2.38e-02
C13 N12 N13 8.25e-06
L13 N12 N13 7.75e-11
R13 N12 N13 1.13e-02
C14 N13 N14 5.12e-06
L14 N13 N14 5.89e-11
R14 N13 N14 9.57e-03
C15 N14 N15 1.75e-11
L15 N14 N15 3.17e-11
R15 N14 N15 7.89e+00
C16 N15 Port2 5.92e-12
L16 N15 Port2 5.84e-11
R16 N15 Port2 1.71e+01
.ENDS GRM21BC81H475ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GRM21BC8YA106KE11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC8YA106KE11 Port1 Port2
C01 Port1 N01 7.56e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.69e-10
R03 N02 N03 3.08e-03
C04 N03 N04 2.44e-04
R04 N03 N04 1.79e+01
C05 N04 N05 3.90e-04
R05 N04 N05 1.10e+00
C06 N05 N06 3.85e-04
R06 N05 N06 1.55e-01
C07 N06 N07 3.26e-04
R07 N06 N07 2.56e-02
C08 N07 N08 2.58e-04
R08 N07 N08 4.40e-03
L09 N08 N09 8.88e-12
R09 N08 N09 5.63e-02
L10 N09 N10 3.26e-11
R10 N09 N10 2.92e-02
L11 N10 N11 2.59e-10
R11 N10 N11 1.64e-02
C12 N11 N12 2.11e-05
L12 N11 N12 6.88e-11
R12 N11 N12 5.96e-03
C13 N12 N13 1.05e-05
L13 N12 N13 6.77e-11
R13 N12 N13 6.34e-03
C14 N13 N14 1.11e-11
L14 N13 N14 6.23e-11
R14 N13 N14 1.31e+01
C15 N14 Port2 5.04e-12
L15 N14 Port2 6.61e-11
R15 N14 Port2 1.81e+01
.ENDS GRM21BC8YA106KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GRM21BC8YA106ME11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC8YA106ME11 Port1 Port2
C01 Port1 N01 7.56e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.69e-10
R03 N02 N03 3.08e-03
C04 N03 N04 2.44e-04
R04 N03 N04 1.79e+01
C05 N04 N05 3.90e-04
R05 N04 N05 1.10e+00
C06 N05 N06 3.85e-04
R06 N05 N06 1.55e-01
C07 N06 N07 3.26e-04
R07 N06 N07 2.56e-02
C08 N07 N08 2.58e-04
R08 N07 N08 4.40e-03
L09 N08 N09 8.88e-12
R09 N08 N09 5.63e-02
L10 N09 N10 3.26e-11
R10 N09 N10 2.92e-02
L11 N10 N11 2.59e-10
R11 N10 N11 1.64e-02
C12 N11 N12 2.11e-05
L12 N11 N12 6.88e-11
R12 N11 N12 5.96e-03
C13 N12 N13 1.05e-05
L13 N12 N13 6.77e-11
R13 N12 N13 6.34e-03
C14 N13 N14 1.11e-11
L14 N13 N14 6.23e-11
R14 N13 N14 1.31e+01
C15 N14 Port2 5.04e-12
L15 N14 Port2 6.61e-11
R15 N14 Port2 1.81e+01
.ENDS GRM21BC8YA106ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+00[uF]/35[V]
* Murata P/N :GRM21BC8YA225KA73
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC8YA225KA73 Port1 Port2
C01 Port1 N01 1.75e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 9.23e-11
R03 N02 N03 6.12e-03
C04 N03 N04 1.55e-05
R04 N03 N04 3.66e+02
C05 N04 N05 4.23e-05
R05 N04 N05 6.79e+00
C06 N05 N06 3.83e-05
R06 N05 N06 7.63e-01
C07 N06 N07 2.95e-05
R07 N06 N07 9.81e-02
C08 N07 N08 2.58e-05
R08 N07 N08 1.11e-02
L09 N08 N09 2.40e-11
R09 N08 N09 3.47e-02
L10 N09 N10 1.48e-10
R10 N09 N10 2.44e-02
C11 N10 N11 5.56e-06
L11 N10 N11 3.52e-11
R11 N10 N11 7.95e-03
C12 N11 N12 1.79e-06
L12 N11 N12 5.26e-11
R12 N11 N12 1.09e-02
C13 N12 N13 1.18e-11
L13 N12 N13 1.11e-10
R13 N12 N13 1.74e+01
C14 N13 Port2 1.92e-12
L14 N13 Port2 1.93e-10
R14 N13 Port2 3.53e+01
.ENDS GRM21BC8YA225KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/2.20e+00[uF]/35[V]
* Murata P/N :GRM21BC8YA225MA73
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC8YA225MA73 Port1 Port2
C01 Port1 N01 1.75e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 9.23e-11
R03 N02 N03 6.12e-03
C04 N03 N04 1.55e-05
R04 N03 N04 3.66e+02
C05 N04 N05 4.23e-05
R05 N04 N05 6.79e+00
C06 N05 N06 3.83e-05
R06 N05 N06 7.63e-01
C07 N06 N07 2.95e-05
R07 N06 N07 9.81e-02
C08 N07 N08 2.58e-05
R08 N07 N08 1.11e-02
L09 N08 N09 2.40e-11
R09 N08 N09 3.47e-02
L10 N09 N10 1.48e-10
R10 N09 N10 2.44e-02
C11 N10 N11 5.56e-06
L11 N10 N11 3.52e-11
R11 N10 N11 7.95e-03
C12 N11 N12 1.79e-06
L12 N11 N12 5.26e-11
R12 N11 N12 1.09e-02
C13 N12 N13 1.18e-11
L13 N12 N13 1.11e-10
R13 N12 N13 1.74e+01
C14 N13 Port2 1.92e-12
L14 N13 Port2 1.93e-10
R14 N13 Port2 3.53e+01
.ENDS GRM21BC8YA225MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GRM21BC8YA475KE51
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC8YA475KE51 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.04e-10
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 1.50e-11
L14 N13 N14 5.47e-11
R14 N13 N14 9.30e+00
C15 N14 Port2 1.96e-12
L15 N14 Port2 1.18e-10
R15 N14 Port2 2.13e+01
.ENDS GRM21BC8YA475KE51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GRM21BC8YA475ME51
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BC8YA475ME51 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.04e-10
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 1.50e-11
L14 N13 N14 5.47e-11
R14 N13 N14 9.30e+00
C15 N14 Port2 1.96e-12
L15 N14 Port2 1.18e-10
R15 N14 Port2 2.13e+01
.ENDS GRM21BC8YA475ME51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/4.70e+01[uF]/2.5[V]
* Murata P/N :GRM21BD70E476ME01
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BD70E476ME01 Port1 Port2
C01 Port1 N01 3.52e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 2.05e-10
R03 N02 N03 1.67e-03
C04 N03 N04 2.28e-03
R04 N03 N04 2.17e+00
C05 N04 N05 2.84e-03
R05 N04 N05 2.60e-01
C06 N05 N06 2.15e-03
R06 N05 N06 4.94e-02
C07 N06 N07 3.03e-03
R07 N06 N07 4.57e-03
C08 N07 N08 3.25e-03
R08 N07 N08 7.62e-04
L09 N08 N09 2.45e-11
R09 N08 N09 4.67e-02
L10 N09 N10 6.10e-11
R10 N09 N10 1.47e-02
L11 N10 N11 4.02e-10
R11 N10 N11 8.76e-03
C12 N11 N12 1.61e-04
L12 N11 N12 6.19e-11
R12 N11 N12 1.45e-03
C13 N12 N13 5.85e-05
L13 N12 N13 8.49e-11
R13 N12 N13 1.97e-03
C14 N13 N14 3.07e-11
L14 N13 N14 4.27e-11
R14 N13 N14 3.61e+00
C15 N14 Port2 1.16e-11
L15 N14 Port2 2.87e-11
R15 N14 Port2 5.32e+00
.ENDS GRM21BD70E476ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRM21BD70J226ME44
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BD70J226ME44 Port1 Port2
C01 Port1 N01 1.70e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.60e-10
R03 N02 N03 2.11e-03
C04 N03 N04 6.67e-04
R04 N03 N04 7.95e+00
C05 N04 N05 7.65e-04
R05 N04 N05 7.74e-01
C06 N05 N06 7.03e-04
R06 N05 N06 9.99e-02
C07 N06 N07 6.45e-04
R07 N06 N07 1.24e-02
C08 N07 N08 6.19e-04
R08 N07 N08 1.97e-03
L09 N08 N09 1.62e-11
R09 N08 N09 5.44e-02
L10 N09 N10 3.66e-11
R10 N09 N10 2.02e-02
L11 N10 N11 3.37e-10
R11 N10 N11 1.34e-02
C12 N11 N12 5.83e-05
L12 N11 N12 6.41e-11
R12 N11 N12 3.35e-03
C13 N12 N13 2.26e-05
L13 N12 N13 8.31e-11
R13 N12 N13 3.61e-03
C14 N13 Port2 4.77e-12
L14 N13 Port2 8.46e-11
R14 N13 Port2 1.47e+01
.ENDS GRM21BD70J226ME44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRM21BD71A226ME44
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BD71A226ME44 Port1 Port2
C01 Port1 N01 1.70e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.60e-10
R03 N02 N03 2.11e-03
C04 N03 N04 6.67e-04
R04 N03 N04 7.95e+00
C05 N04 N05 7.65e-04
R05 N04 N05 7.74e-01
C06 N05 N06 7.03e-04
R06 N05 N06 9.99e-02
C07 N06 N07 6.45e-04
R07 N06 N07 1.24e-02
C08 N07 N08 6.19e-04
R08 N07 N08 1.97e-03
L09 N08 N09 1.62e-11
R09 N08 N09 5.44e-02
L10 N09 N10 3.66e-11
R10 N09 N10 2.02e-02
L11 N10 N11 3.37e-10
R11 N10 N11 1.34e-02
C12 N11 N12 5.83e-05
L12 N11 N12 6.41e-11
R12 N11 N12 3.35e-03
C13 N12 N13 2.26e-05
L13 N12 N13 8.31e-11
R13 N12 N13 3.61e-03
C14 N13 Port2 4.77e-12
L14 N13 Port2 8.46e-11
R14 N13 Port2 1.47e+01
.ENDS GRM21BD71A226ME44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM21BD71C475KA12
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BD71C475KA12 Port1 Port2
C01 Port1 N01 3.34e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.41e-10
R03 N02 N03 3.82e-03
C04 N03 N04 8.37e-05
R04 N03 N04 5.77e+01
C05 N04 N05 1.09e-04
R05 N04 N05 3.92e+00
C06 N05 N06 8.88e-05
R06 N05 N06 4.76e-01
C07 N06 N07 7.40e-05
R07 N06 N07 5.47e-02
C08 N07 N08 1.32e-04
R08 N07 N08 5.71e-03
C09 N08 N09 9.23e-05
R09 N08 N09 3.60e-03
L10 N09 N10 2.78e-11
R10 N09 N10 4.43e-02
L11 N10 N11 2.61e-10
R11 N10 N11 2.43e-02
C12 N11 N12 1.15e-05
L12 N11 N12 4.50e-11
R12 N11 N12 7.90e-03
C13 N12 N13 5.69e-06
L13 N12 N13 4.40e-11
R13 N12 N13 6.99e-03
C14 N13 N14 1.43e-11
L14 N13 N14 4.66e-11
R14 N13 N14 7.20e+00
C15 N14 Port2 4.46e-12
L15 N14 Port2 6.55e-11
R15 N14 Port2 6.03e+00
.ENDS GRM21BD71C475KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM21BD71C475MA12
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BD71C475MA12 Port1 Port2
C01 Port1 N01 3.34e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.41e-10
R03 N02 N03 3.82e-03
C04 N03 N04 8.37e-05
R04 N03 N04 5.77e+01
C05 N04 N05 1.09e-04
R05 N04 N05 3.92e+00
C06 N05 N06 8.88e-05
R06 N05 N06 4.76e-01
C07 N06 N07 7.40e-05
R07 N06 N07 5.47e-02
C08 N07 N08 1.32e-04
R08 N07 N08 5.71e-03
C09 N08 N09 9.23e-05
R09 N08 N09 3.60e-03
L10 N09 N10 2.78e-11
R10 N09 N10 4.43e-02
L11 N10 N11 2.61e-10
R11 N10 N11 2.43e-02
C12 N11 N12 1.15e-05
L12 N11 N12 4.50e-11
R12 N11 N12 7.90e-03
C13 N12 N13 5.69e-06
L13 N12 N13 4.40e-11
R13 N12 N13 6.99e-03
C14 N13 N14 1.43e-11
L14 N13 N14 4.66e-11
R14 N13 N14 7.20e+00
C15 N14 Port2 4.46e-12
L15 N14 Port2 6.55e-11
R15 N14 Port2 6.03e+00
.ENDS GRM21BD71C475MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRM21BD71H225KE01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BD71H225KE01 Port1 Port2
C01 Port1 N01 2.16e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.96e-10
R03 N02 N03 3.79e-03
C04 N03 N04 2.29e-04
R04 N03 N04 4.54e+00
C05 N04 N05 2.01e-04
R05 N04 N05 6.98e-01
C06 N05 N06 2.05e-04
R06 N05 N06 9.43e-02
C07 N06 N07 2.18e-04
R07 N06 N07 1.48e-02
C08 N07 N08 1.83e-04
R08 N07 N08 4.18e-03
L09 N08 N09 2.44e-11
R09 N08 N09 7.30e-02
L10 N09 N10 1.79e-10
R10 N09 N10 3.15e-02
C11 N10 N11 4.77e-06
L11 N10 N11 8.09e-11
R11 N10 N11 1.49e-02
C12 N11 N12 2.05e-06
L12 N11 N12 8.12e-11
R12 N11 N12 1.45e-02
C13 N12 N13 1.84e-11
L13 N12 N13 3.51e-11
R13 N12 N13 4.19e+00
C14 N13 Port2 1.99e-11
L14 N13 Port2 1.63e-11
R14 N13 Port2 5.20e+00
.ENDS GRM21BD71H225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/2.20e+00[uF]/100[V]
* Murata P/N :GRM21BD72A225KE01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BD72A225KE01 Port1 Port2
C01 Port1 N01 2.16e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.96e-10
R03 N02 N03 3.79e-03
C04 N03 N04 2.29e-04
R04 N03 N04 4.54e+00
C05 N04 N05 2.01e-04
R05 N04 N05 6.98e-01
C06 N05 N06 2.05e-04
R06 N05 N06 9.43e-02
C07 N06 N07 2.18e-04
R07 N06 N07 1.48e-02
C08 N07 N08 1.83e-04
R08 N07 N08 4.18e-03
L09 N08 N09 2.44e-11
R09 N08 N09 7.30e-02
L10 N09 N10 1.79e-10
R10 N09 N10 3.15e-02
C11 N10 N11 4.77e-06
L11 N10 N11 8.09e-11
R11 N10 N11 1.49e-02
C12 N11 N12 2.05e-06
L12 N11 N12 8.12e-11
R12 N11 N12 1.45e-02
C13 N12 N13 1.84e-11
L13 N12 N13 3.51e-11
R13 N12 N13 4.19e+00
C14 N13 Port2 1.99e-11
L14 N13 Port2 1.63e-11
R14 N13 Port2 5.20e+00
.ENDS GRM21BD72A225KE01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/2.20e+00[uF]/100[V]
* Murata P/N :GRM21BD72A225ME01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BD72A225ME01 Port1 Port2
C01 Port1 N01 2.16e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.96e-10
R03 N02 N03 3.79e-03
C04 N03 N04 2.29e-04
R04 N03 N04 4.54e+00
C05 N04 N05 2.01e-04
R05 N04 N05 6.98e-01
C06 N05 N06 2.05e-04
R06 N05 N06 9.43e-02
C07 N06 N07 2.18e-04
R07 N06 N07 1.48e-02
C08 N07 N08 1.83e-04
R08 N07 N08 4.18e-03
L09 N08 N09 2.44e-11
R09 N08 N09 7.30e-02
L10 N09 N10 1.79e-10
R10 N09 N10 3.15e-02
C11 N10 N11 4.77e-06
L11 N10 N11 8.09e-11
R11 N10 N11 1.49e-02
C12 N11 N12 2.05e-06
L12 N11 N12 8.12e-11
R12 N11 N12 1.45e-02
C13 N12 N13 1.84e-11
L13 N12 N13 3.51e-11
R13 N12 N13 4.19e+00
C14 N13 Port2 1.99e-11
L14 N13 Port2 1.63e-11
R14 N13 Port2 5.20e+00
.ENDS GRM21BD72A225ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6T(-55to105[deg])/4.70e+01[uF]/4[V]
* Murata P/N :GRM21BD80G476ME01
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BD80G476ME01 Port1 Port2
C01 Port1 N01 3.87e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.38e-10
R03 N02 N03 1.61e-03
C04 N03 N04 2.31e-03
R04 N03 N04 1.84e+00
C05 N04 N05 2.93e-03
R05 N04 N05 1.90e-01
C06 N05 N06 2.01e-03
R06 N05 N06 3.63e-02
C07 N06 N07 1.97e-03
R07 N06 N07 2.71e-03
L08 N07 N08 2.21e-11
R08 N07 N08 4.46e-02
L09 N08 N09 6.25e-11
R09 N08 N09 1.85e-02
L10 N09 N10 3.76e-10
R10 N09 N10 9.31e-03
C11 N10 N11 1.14e-04
L11 N10 N11 9.13e-11
R11 N10 N11 1.58e-03
C12 N11 N12 6.77e-05
L12 N11 N12 8.12e-11
R12 N11 N12 1.81e-03
C13 N12 N13 3.69e-11
L13 N12 N13 4.60e-11
R13 N12 N13 2.07e+00
C14 N13 Port2 2.45e-12
L14 N13 Port2 8.30e-11
R14 N13 Port2 1.95e+01
.ENDS GRM21BD80G476ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7U(-55to125[deg])/2.20e+01[uF]/4[V]
* Murata P/N :GRM21BE70G226ME51
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BE70G226ME51 Port1 Port2
C01 Port1 N01 1.41e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.44e-10
R03 N02 N03 2.43e-03
C04 N03 N04 2.83e-04
R04 N03 N04 2.01e+01
C05 N04 N05 3.85e-04
R05 N04 N05 1.39e+00
C06 N05 N06 3.52e-04
R06 N05 N06 1.52e-01
C07 N06 N07 2.64e-04
R07 N06 N07 1.93e-02
C08 N07 N08 3.46e-04
R08 N07 N08 1.96e-03
L09 N08 N09 1.53e-11
R09 N08 N09 8.38e-02
L10 N09 N10 4.59e-11
R10 N09 N10 2.50e-02
L11 N10 N11 3.75e-10
R11 N10 N11 1.39e-02
C12 N11 N12 3.43e-05
L12 N11 N12 7.23e-11
R12 N11 N12 3.39e-03
C13 N12 N13 7.50e-05
L13 N12 N13 1.79e-11
R13 N12 N13 2.21e-03
C14 N13 N14 1.45e-11
L14 N13 N14 5.81e-11
R14 N13 N14 7.85e+00
C15 N14 Port2 8.35e-12
L15 N14 Port2 3.97e-11
R15 N14 Port2 5.40e+00
.ENDS GRM21BE70G226ME51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7U(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM21BE71C475KA12
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BE71C475KA12 Port1 Port2
C01 Port1 N01 3.34e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.41e-10
R03 N02 N03 3.82e-03
C04 N03 N04 8.37e-05
R04 N03 N04 5.77e+01
C05 N04 N05 1.09e-04
R05 N04 N05 3.92e+00
C06 N05 N06 8.88e-05
R06 N05 N06 4.76e-01
C07 N06 N07 7.40e-05
R07 N06 N07 5.47e-02
C08 N07 N08 1.32e-04
R08 N07 N08 5.71e-03
C09 N08 N09 9.23e-05
R09 N08 N09 3.60e-03
L10 N09 N10 2.78e-11
R10 N09 N10 4.43e-02
L11 N10 N11 2.61e-10
R11 N10 N11 2.43e-02
C12 N11 N12 1.15e-05
L12 N11 N12 4.50e-11
R12 N11 N12 7.90e-03
C13 N12 N13 5.69e-06
L13 N12 N13 4.40e-11
R13 N12 N13 6.99e-03
C14 N13 N14 1.43e-11
L14 N13 N14 4.66e-11
R14 N13 N14 7.20e+00
C15 N14 Port2 4.46e-12
L15 N14 Port2 6.55e-11
R15 N14 Port2 6.03e+00
.ENDS GRM21BE71C475KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7U(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM21BE71C475MA12
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BE71C475MA12 Port1 Port2
C01 Port1 N01 3.34e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.41e-10
R03 N02 N03 3.82e-03
C04 N03 N04 8.37e-05
R04 N03 N04 5.77e+01
C05 N04 N05 1.09e-04
R05 N04 N05 3.92e+00
C06 N05 N06 8.88e-05
R06 N05 N06 4.76e-01
C07 N06 N07 7.40e-05
R07 N06 N07 5.47e-02
C08 N07 N08 1.32e-04
R08 N07 N08 5.71e-03
C09 N08 N09 9.23e-05
R09 N08 N09 3.60e-03
L10 N09 N10 2.78e-11
R10 N09 N10 4.43e-02
L11 N10 N11 2.61e-10
R11 N10 N11 2.43e-02
C12 N11 N12 1.15e-05
L12 N11 N12 4.50e-11
R12 N11 N12 7.90e-03
C13 N12 N13 5.69e-06
L13 N12 N13 4.40e-11
R13 N12 N13 6.99e-03
C14 N13 N14 1.43e-11
L14 N13 N14 4.66e-11
R14 N13 N14 7.20e+00
C15 N14 Port2 4.46e-12
L15 N14 Port2 6.55e-11
R15 N14 Port2 6.03e+00
.ENDS GRM21BE71C475MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :GRM21BR10J105KC01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR10J105KC01 Port1 Port2
C01 Port1 N01 9.65e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 2.25e-10
R03 N02 N03 4.51e-03
C04 N03 N04 8.44e-05
R04 N03 N04 6.29e+01
C05 N04 N05 1.37e-04
R05 N04 N05 2.85e+00
C06 N05 N06 1.25e-04
R06 N05 N06 3.66e-01
C07 N06 N07 1.22e-04
R07 N06 N07 4.44e-02
C08 N07 N08 1.15e-04
R08 N07 N08 7.22e-03
L09 N08 N09 2.95e-11
R09 N08 N09 1.28e-01
L10 N09 N10 2.05e-10
R10 N09 N10 3.43e-02
C11 N10 N11 4.48e-06
L11 N10 N11 3.70e-11
R11 N10 N11 1.50e-02
C12 N11 N12 1.55e-06
L12 N11 N12 5.13e-11
R12 N11 N12 1.74e-02
C13 N12 N13 7.56e-12
L13 N12 N13 8.71e-11
R13 N12 N13 9.19e+00
C14 N13 Port2 1.10e-11
L14 N13 Port2 3.44e-11
R14 N13 Port2 1.38e+01
.ENDS GRM21BR10J105KC01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRM21BR11A105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11A105KA01 Port1 Port2
C01 Port1 N01 9.33e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.89e-10
R03 N02 N03 4.90e-03
C04 N03 N04 1.81e-04
R04 N03 N04 6.47e+00
C05 N04 N05 1.23e-04
R05 N04 N05 7.97e-01
C06 N05 N06 1.13e-04
R06 N05 N06 9.92e-02
C07 N06 N07 7.87e-05
R07 N06 N07 1.33e-02
L08 N07 N08 1.81e-11
R08 N07 N08 5.44e-02
L09 N08 N09 1.88e-10
R09 N08 N09 3.80e-02
C10 N09 N10 3.05e-06
L10 N09 N10 5.20e-11
R10 N09 N10 1.67e-02
C11 N10 N11 1.74e-06
L11 N10 N11 4.23e-11
R11 N10 N11 1.75e-02
C12 N11 N12 8.19e-12
L12 N11 N12 9.37e-11
R12 N11 N12 1.03e+01
C13 N12 Port2 5.87e-12
L13 N12 Port2 5.67e-11
R13 N12 Port2 1.96e+01
.ENDS GRM21BR11A105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRM21BR11C105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11C105KA01 Port1 Port2
C01 Port1 N01 9.33e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.89e-10
R03 N02 N03 4.90e-03
C04 N03 N04 1.81e-04
R04 N03 N04 6.47e+00
C05 N04 N05 1.23e-04
R05 N04 N05 7.97e-01
C06 N05 N06 1.13e-04
R06 N05 N06 9.92e-02
C07 N06 N07 7.87e-05
R07 N06 N07 1.33e-02
L08 N07 N08 1.81e-11
R08 N07 N08 5.44e-02
L09 N08 N09 1.88e-10
R09 N08 N09 3.80e-02
C10 N09 N10 3.05e-06
L10 N09 N10 5.20e-11
R10 N09 N10 1.67e-02
C11 N10 N11 1.74e-06
L11 N10 N11 4.23e-11
R11 N10 N11 1.75e-02
C12 N11 N12 8.19e-12
L12 N11 N12 9.37e-11
R12 N11 N12 1.03e+01
C13 N12 Port2 5.87e-12
L13 N12 Port2 5.67e-11
R13 N12 Port2 1.96e+01
.ENDS GRM21BR11C105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GRM21BR11C224KA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11C224KA01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 8.13e-11
R03 N02 N03 1.05e-02
C04 N03 N04 3.32e-05
R04 N03 N04 1.20e+02
C05 N04 N05 7.33e-05
R05 N04 N05 1.14e+01
C06 N05 N06 4.01e-05
R06 N05 N06 5.11e+00
C07 N06 N07 4.58e-05
R07 N06 N07 7.56e-01
C08 N07 N08 3.44e-05
R08 N07 N08 1.81e-01
C09 N08 N09 3.92e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.87e-05
R10 N09 N10 1.34e-02
C11 N10 N11 1.98e-05
R11 N10 N11 1.69e-03
C12 N11 N12 5.30e+00
R12 N11 N12 3.00e-06
L13 N12 N13 1.37e-10
R13 N12 N13 5.78e-02
C14 N13 N14 1.22e-06
L14 N13 N14 2.66e-11
R14 N13 N14 1.76e-02
C15 N14 N15 3.20e-07
L15 N14 N15 4.28e-11
R15 N14 N15 2.44e-02
C16 N15 N16 8.80e-12
L16 N15 N16 1.19e-10
R16 N15 N16 9.16e+00
C17 N16 Port2 1.40e-12
L17 N16 Port2 2.16e-10
R17 N16 Port2 2.71e+01
.ENDS GRM21BR11C224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GRM21BR11C224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11C224MA01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 8.13e-11
R03 N02 N03 1.05e-02
C04 N03 N04 3.32e-05
R04 N03 N04 1.20e+02
C05 N04 N05 7.33e-05
R05 N04 N05 1.14e+01
C06 N05 N06 4.01e-05
R06 N05 N06 5.11e+00
C07 N06 N07 4.58e-05
R07 N06 N07 7.56e-01
C08 N07 N08 3.44e-05
R08 N07 N08 1.81e-01
C09 N08 N09 3.92e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.87e-05
R10 N09 N10 1.34e-02
C11 N10 N11 1.98e-05
R11 N10 N11 1.69e-03
C12 N11 N12 5.30e+00
R12 N11 N12 3.00e-06
L13 N12 N13 1.37e-10
R13 N12 N13 5.78e-02
C14 N13 N14 1.22e-06
L14 N13 N14 2.66e-11
R14 N13 N14 1.76e-02
C15 N14 N15 3.20e-07
L15 N14 N15 4.28e-11
R15 N14 N15 2.44e-02
C16 N15 N16 8.80e-12
L16 N15 N16 1.19e-10
R16 N15 N16 9.16e+00
C17 N16 Port2 1.40e-12
L17 N16 Port2 2.16e-10
R17 N16 Port2 2.71e+01
.ENDS GRM21BR11C224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GRM21BR11E104KA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11E104KA01 Port1 Port2
C01 Port1 N01 9.64e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.44e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.45e-05
R04 N03 N04 1.10e+00
C05 N04 N05 8.53e-06
R05 N04 N05 4.23e-01
C06 N05 N06 1.00e-05
R06 N05 N06 6.88e-02
C07 N06 N07 1.56e-05
R07 N06 N07 1.59e-02
C08 N07 N08 9.93e-06
R08 N07 N08 5.77e-03
L09 N08 N09 1.43e-10
R09 N08 N09 8.30e-02
L10 N09 N10 5.40e-13
R10 N09 N10 5.13e-03
C11 N10 N11 5.81e-07
L11 N10 N11 2.53e-11
R11 N10 N11 3.22e-02
C12 N11 N12 1.40e-07
L12 N11 N12 5.04e-11
R12 N11 N12 4.66e-02
C13 N12 N13 1.08e-11
L13 N12 N13 1.01e-10
R13 N12 N13 9.45e+00
C14 N13 Port2 2.59e-12
L14 N13 Port2 1.34e-10
R14 N13 Port2 1.59e+01
.ENDS GRM21BR11E104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GRM21BR11E104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11E104MA01 Port1 Port2
C01 Port1 N01 9.64e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.44e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.45e-05
R04 N03 N04 1.10e+00
C05 N04 N05 8.53e-06
R05 N04 N05 4.23e-01
C06 N05 N06 1.00e-05
R06 N05 N06 6.88e-02
C07 N06 N07 1.56e-05
R07 N06 N07 1.59e-02
C08 N07 N08 9.93e-06
R08 N07 N08 5.77e-03
L09 N08 N09 1.43e-10
R09 N08 N09 8.30e-02
L10 N09 N10 5.40e-13
R10 N09 N10 5.13e-03
C11 N10 N11 5.81e-07
L11 N10 N11 2.53e-11
R11 N10 N11 3.22e-02
C12 N11 N12 1.40e-07
L12 N11 N12 5.04e-11
R12 N11 N12 4.66e-02
C13 N12 N13 1.08e-11
L13 N12 N13 1.01e-10
R13 N12 N13 9.45e+00
C14 N13 Port2 2.59e-12
L14 N13 Port2 1.34e-10
R14 N13 Port2 1.59e+01
.ENDS GRM21BR11E104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRM21BR11E105KA99
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11E105KA99 Port1 Port2
C01 Port1 N01 1.02e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 1.06e-10
R03 N02 N03 4.89e-03
C04 N03 N04 2.36e-05
R04 N03 N04 3.04e+02
C05 N04 N05 1.12e-04
R05 N04 N05 3.04e+00
C06 N05 N06 1.14e-04
R06 N05 N06 3.00e-01
C07 N06 N07 9.26e-05
R07 N06 N07 3.66e-02
C08 N07 N08 6.76e-05
R08 N07 N08 5.29e-03
L09 N08 N09 1.84e-11
R09 N08 N09 5.34e-02
L10 N09 N10 1.99e-10
R10 N09 N10 3.69e-02
C11 N10 N11 2.43e-06
L11 N10 N11 7.08e-11
R11 N10 N11 1.57e-02
C12 N11 N12 1.83e-06
L12 N11 N12 4.21e-11
R12 N11 N12 1.57e-02
C13 N12 N13 1.51e-11
L13 N12 N13 7.39e-11
R13 N12 N13 8.53e+00
C14 N13 Port2 2.10e-12
L14 N13 Port2 1.47e-10
R14 N13 Port2 2.33e+01
.ENDS GRM21BR11E105KA99
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GRM21BR11E154KA01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11E154KA01 Port1 Port2
C01 Port1 N01 1.49e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 2.16e-10
R03 N02 N03 1.36e-02
C04 N03 N04 1.98e-05
R04 N03 N04 2.01e+02
C05 N04 N05 3.78e-05
R05 N04 N05 1.91e+01
C06 N05 N06 2.60e-05
R06 N05 N06 4.70e+00
C07 N06 N07 2.69e-05
R07 N06 N07 7.11e-01
C08 N07 N08 2.02e-05
R08 N07 N08 1.22e-01
C09 N08 N09 9.76e-06
R09 N08 N09 2.24e-02
L10 N09 N10 1.41e-10
R10 N09 N10 6.41e-02
L11 N10 N11 8.96e-12
R11 N10 N11 2.99e-02
C12 N11 N12 9.52e-07
L12 N11 N12 2.55e-11
R12 N11 N12 1.77e-02
C13 N12 N13 2.56e-07
L13 N12 N13 3.19e-11
R13 N12 N13 2.07e-02
C14 N13 N14 7.73e-12
L14 N13 N14 1.42e-10
R14 N13 N14 1.07e+01
C15 N14 Port2 4.83e-12
L15 N14 Port2 6.46e-11
R15 N14 Port2 2.55e+01
.ENDS GRM21BR11E154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GRM21BR11E154MA01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11E154MA01 Port1 Port2
C01 Port1 N01 1.49e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 2.16e-10
R03 N02 N03 1.36e-02
C04 N03 N04 1.98e-05
R04 N03 N04 2.01e+02
C05 N04 N05 3.78e-05
R05 N04 N05 1.91e+01
C06 N05 N06 2.60e-05
R06 N05 N06 4.70e+00
C07 N06 N07 2.69e-05
R07 N06 N07 7.11e-01
C08 N07 N08 2.02e-05
R08 N07 N08 1.22e-01
C09 N08 N09 9.76e-06
R09 N08 N09 2.24e-02
L10 N09 N10 1.41e-10
R10 N09 N10 6.41e-02
L11 N10 N11 8.96e-12
R11 N10 N11 2.99e-02
C12 N11 N12 9.52e-07
L12 N11 N12 2.55e-11
R12 N11 N12 1.77e-02
C13 N12 N13 2.56e-07
L13 N12 N13 3.19e-11
R13 N12 N13 2.07e-02
C14 N13 N14 7.73e-12
L14 N13 N14 1.42e-10
R14 N13 N14 1.07e+01
C15 N14 Port2 4.83e-12
L15 N14 Port2 6.46e-11
R15 N14 Port2 2.55e+01
.ENDS GRM21BR11E154MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRM21BR11E224KA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11E224KA01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 8.13e-11
R03 N02 N03 1.05e-02
C04 N03 N04 3.32e-05
R04 N03 N04 1.20e+02
C05 N04 N05 7.33e-05
R05 N04 N05 1.14e+01
C06 N05 N06 4.01e-05
R06 N05 N06 5.11e+00
C07 N06 N07 4.58e-05
R07 N06 N07 7.56e-01
C08 N07 N08 3.44e-05
R08 N07 N08 1.81e-01
C09 N08 N09 3.92e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.87e-05
R10 N09 N10 1.34e-02
C11 N10 N11 1.98e-05
R11 N10 N11 1.69e-03
C12 N11 N12 5.30e+00
R12 N11 N12 3.00e-06
L13 N12 N13 1.37e-10
R13 N12 N13 5.78e-02
C14 N13 N14 1.22e-06
L14 N13 N14 2.66e-11
R14 N13 N14 1.76e-02
C15 N14 N15 3.20e-07
L15 N14 N15 4.28e-11
R15 N14 N15 2.44e-02
C16 N15 N16 8.80e-12
L16 N15 N16 1.19e-10
R16 N15 N16 9.16e+00
C17 N16 Port2 1.40e-12
L17 N16 Port2 2.16e-10
R17 N16 Port2 2.71e+01
.ENDS GRM21BR11E224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRM21BR11E224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11E224MA01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 8.13e-11
R03 N02 N03 1.05e-02
C04 N03 N04 3.32e-05
R04 N03 N04 1.20e+02
C05 N04 N05 7.33e-05
R05 N04 N05 1.14e+01
C06 N05 N06 4.01e-05
R06 N05 N06 5.11e+00
C07 N06 N07 4.58e-05
R07 N06 N07 7.56e-01
C08 N07 N08 3.44e-05
R08 N07 N08 1.81e-01
C09 N08 N09 3.92e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.87e-05
R10 N09 N10 1.34e-02
C11 N10 N11 1.98e-05
R11 N10 N11 1.69e-03
C12 N11 N12 5.30e+00
R12 N11 N12 3.00e-06
L13 N12 N13 1.37e-10
R13 N12 N13 5.78e-02
C14 N13 N14 1.22e-06
L14 N13 N14 2.66e-11
R14 N13 N14 1.76e-02
C15 N14 N15 3.20e-07
L15 N14 N15 4.28e-11
R15 N14 N15 2.44e-02
C16 N15 N16 8.80e-12
L16 N15 N16 1.19e-10
R16 N15 N16 9.16e+00
C17 N16 Port2 1.40e-12
L17 N16 Port2 2.16e-10
R17 N16 Port2 2.71e+01
.ENDS GRM21BR11E224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/6.80e-01[uF]/25[V]
* Murata P/N :GRM21BR11E684KA88
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11E684KA88 Port1 Port2
C01 Port1 N01 6.68e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.36e-10
R03 N02 N03 5.56e-03
C04 N03 N04 8.63e-05
R04 N03 N04 4.61e+01
C05 N04 N05 1.16e-04
R05 N04 N05 5.81e+00
C06 N05 N06 1.07e-04
R06 N05 N06 1.06e+00
C07 N06 N07 8.55e-05
R07 N06 N07 2.06e-01
C08 N07 N08 7.17e-05
R08 N07 N08 2.99e-02
C09 N08 N09 5.38e-05
R09 N08 N09 9.21e-03
L10 N09 N10 1.79e-10
R10 N09 N10 4.05e-02
L11 N10 N11 1.07e-11
R11 N10 N11 3.28e-02
C12 N11 N12 2.57e-06
L12 N11 N12 4.13e-11
R12 N11 N12 1.57e-02
C13 N12 N13 1.05e-06
L13 N12 N13 4.51e-11
R13 N12 N13 1.94e-02
C14 N13 N14 1.10e-11
L14 N13 N14 9.89e-11
R14 N13 N14 1.08e+01
C15 N14 Port2 1.83e-12
L15 N14 Port2 1.64e-10
R15 N14 Port2 2.44e+01
.ENDS GRM21BR11E684KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRM21BR11H104KA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11H104KA01 Port1 Port2
C01 Port1 N01 9.67e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 7.66e-11
R03 N02 N03 1.45e-02
C04 N03 N04 1.59e-05
R04 N03 N04 2.50e+02
C05 N04 N05 2.80e-05
R05 N04 N05 2.22e+01
C06 N05 N06 1.82e-05
R06 N05 N06 7.71e+00
C07 N06 N07 1.87e-05
R07 N06 N07 1.01e+00
C08 N07 N08 4.13e-05
R08 N07 N08 1.93e-01
C09 N08 N09 2.21e-05
R09 N08 N09 7.70e-02
C10 N09 N10 1.37e-05
R10 N09 N10 3.92e-02
C11 N10 N11 7.58e-06
R11 N10 N11 1.26e-02
L12 N11 N12 4.51e-11
R12 N11 N12 2.65e-01
L13 N12 N13 1.20e-10
R13 N12 N13 8.93e-02
C14 N13 N14 4.91e-07
L14 N13 N14 2.99e-11
R14 N13 N14 3.39e-02
C15 N14 N15 9.88e-08
L15 N14 N15 6.61e-11
R15 N14 N15 4.82e-02
C16 N15 N16 1.67e-11
L16 N15 N16 5.76e-11
R16 N15 N16 5.64e+00
C17 N16 N17 3.41e-12
L17 N16 N17 1.11e-10
R17 N16 N17 1.35e+01
C18 N17 Port2 1.95e-12
L18 N17 Port2 9.64e-11
R18 N17 Port2 1.00e+05
.ENDS GRM21BR11H104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRM21BR11H104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11H104MA01 Port1 Port2
C01 Port1 N01 9.67e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 7.66e-11
R03 N02 N03 1.45e-02
C04 N03 N04 1.59e-05
R04 N03 N04 2.50e+02
C05 N04 N05 2.80e-05
R05 N04 N05 2.22e+01
C06 N05 N06 1.82e-05
R06 N05 N06 7.71e+00
C07 N06 N07 1.87e-05
R07 N06 N07 1.01e+00
C08 N07 N08 4.13e-05
R08 N07 N08 1.93e-01
C09 N08 N09 2.21e-05
R09 N08 N09 7.70e-02
C10 N09 N10 1.37e-05
R10 N09 N10 3.92e-02
C11 N10 N11 7.58e-06
R11 N10 N11 1.26e-02
L12 N11 N12 4.51e-11
R12 N11 N12 2.65e-01
L13 N12 N13 1.20e-10
R13 N12 N13 8.93e-02
C14 N13 N14 4.91e-07
L14 N13 N14 2.99e-11
R14 N13 N14 3.39e-02
C15 N14 N15 9.88e-08
L15 N14 N15 6.61e-11
R15 N14 N15 4.82e-02
C16 N15 N16 1.67e-11
L16 N15 N16 5.76e-11
R16 N15 N16 5.64e+00
C17 N16 N17 3.41e-12
L17 N16 N17 1.11e-10
R17 N16 N17 1.35e+01
C18 N17 Port2 1.95e-12
L18 N17 Port2 9.64e-11
R18 N17 Port2 1.00e+05
.ENDS GRM21BR11H104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRM21BR11H473KA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11H473KA01 Port1 Port2
C01 Port1 N01 4.69e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 2.04e-02
C04 N03 N04 6.37e-06
R04 N03 N04 5.38e+02
C05 N04 N05 7.89e-06
R05 N04 N05 6.33e+01
C06 N05 N06 6.97e-06
R06 N05 N06 8.34e+00
C07 N06 N07 8.44e-06
R07 N06 N07 9.13e-01
C08 N07 N08 6.32e-06
R08 N07 N08 2.80e-01
C09 N08 N09 3.65e-06
R09 N08 N09 6.23e-02
C10 N09 N10 2.57e-06
R10 N09 N10 1.34e-02
L11 N10 N11 1.02e-10
R11 N10 N11 1.45e-01
C12 N11 N12 2.32e-07
L12 N11 N12 3.18e-11
R12 N11 N12 4.95e-02
C13 N12 N13 3.38e-08
L13 N12 N13 6.26e-11
R13 N12 N13 5.68e-02
C14 N13 N14 1.67e-11
L14 N13 N14 7.82e-11
R14 N13 N14 6.21e+00
C15 N14 Port2 1.83e-12
L15 N14 Port2 1.62e-10
R15 N14 Port2 2.25e+01
.ENDS GRM21BR11H473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRM21BR11H473MA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11H473MA01 Port1 Port2
C01 Port1 N01 4.69e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 2.04e-02
C04 N03 N04 6.37e-06
R04 N03 N04 5.38e+02
C05 N04 N05 7.89e-06
R05 N04 N05 6.33e+01
C06 N05 N06 6.97e-06
R06 N05 N06 8.34e+00
C07 N06 N07 8.44e-06
R07 N06 N07 9.13e-01
C08 N07 N08 6.32e-06
R08 N07 N08 2.80e-01
C09 N08 N09 3.65e-06
R09 N08 N09 6.23e-02
C10 N09 N10 2.57e-06
R10 N09 N10 1.34e-02
L11 N10 N11 1.02e-10
R11 N10 N11 1.45e-01
C12 N11 N12 2.32e-07
L12 N11 N12 3.18e-11
R12 N11 N12 4.95e-02
C13 N12 N13 3.38e-08
L13 N12 N13 6.26e-11
R13 N12 N13 5.68e-02
C14 N13 N14 1.67e-11
L14 N13 N14 7.82e-11
R14 N13 N14 6.21e+00
C15 N14 Port2 1.83e-12
L15 N14 Port2 1.62e-10
R15 N14 Port2 2.25e+01
.ENDS GRM21BR11H473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/R(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GRM21BR11H683KA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR11H683KA01 Port1 Port2
C01 Port1 N01 6.81e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.71e-10
R03 N02 N03 1.98e-02
C04 N03 N04 9.16e-06
R04 N03 N04 4.03e+02
C05 N04 N05 1.40e-05
R05 N04 N05 4.13e+01
C06 N05 N06 1.12e-05
R06 N05 N06 8.43e+00
C07 N06 N07 1.02e-05
R07 N06 N07 1.11e+00
C08 N07 N08 9.18e-06
R08 N07 N08 2.13e-01
C09 N08 N09 6.68e-06
R09 N08 N09 4.00e-02
C10 N09 N10 3.17e-06
R10 N09 N10 1.22e-02
L11 N10 N11 1.31e-10
R11 N10 N11 1.07e-01
C12 N11 N12 6.53e-07
L12 N11 N12 1.65e-11
R12 N11 N12 2.41e-02
C13 N12 N13 6.83e-08
L13 N12 N13 7.25e-11
R13 N12 N13 4.98e-02
C14 N13 N14 8.68e-12
L14 N13 N14 1.29e-10
R14 N13 N14 9.84e+00
C15 N14 Port2 3.88e-12
L15 N14 Port2 9.77e-11
R15 N14 Port2 2.08e+01
.ENDS GRM21BR11H683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+02[uF]/2.5[V]
* Murata P/N :GRM21BR60E107ME15
* Property : C = 1.00e+02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR60E107ME15 Port1 Port2
C01 Port1 N01 7.31e-05
R01 Port1 N01 5.00e+05
L02 N01 N02 1.95e-10
R03 N02 N03 1.33e-03
C04 N03 N04 4.16e-03
R04 N03 N04 8.33e-01
C05 N04 N05 5.06e-03
R05 N04 N05 6.43e-02
C06 N05 N06 4.91e-03
R06 N05 N06 1.09e-02
C07 N06 N07 8.50e-03
R07 N06 N07 5.04e-04
L08 N07 N08 1.53e-11
R08 N07 N08 6.08e-02
L09 N08 N09 2.67e-11
R09 N08 N09 2.12e-02
L10 N09 N10 7.82e-11
R10 N09 N10 1.23e-02
L11 N10 N11 4.17e-10
R11 N10 N11 6.65e-03
C12 N11 N12 1.73e-04
L12 N11 N12 1.28e-10
R12 N11 N12 1.08e-03
C13 N12 N13 1.53e-04
L13 N12 N13 8.20e-11
R13 N12 N13 8.47e-04
C14 N13 Port2 3.16e-11
L14 N13 Port2 4.12e-11
R14 N13 Port2 2.24e+00
.ENDS GRM21BR60E107ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+02[uF]/4[V]
* Murata P/N :GRM21BR60G107ME11
* Property : C = 1.00e+02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR60G107ME11 Port1 Port2
C01 Port1 N01 7.31e-05
R01 Port1 N01 5.00e+05
L02 N01 N02 1.95e-10
R03 N02 N03 1.33e-03
C04 N03 N04 4.16e-03
R04 N03 N04 8.33e-01
C05 N04 N05 5.06e-03
R05 N04 N05 6.43e-02
C06 N05 N06 4.91e-03
R06 N05 N06 1.09e-02
C07 N06 N07 8.50e-03
R07 N06 N07 5.04e-04
L08 N07 N08 1.53e-11
R08 N07 N08 6.08e-02
L09 N08 N09 2.67e-11
R09 N08 N09 2.12e-02
L10 N09 N10 7.82e-11
R10 N09 N10 1.23e-02
L11 N10 N11 4.17e-10
R11 N10 N11 6.65e-03
C12 N11 N12 1.73e-04
L12 N11 N12 1.28e-10
R12 N11 N12 1.08e-03
C13 N12 N13 1.53e-04
L13 N12 N13 8.20e-11
R13 N12 N13 8.47e-04
C14 N13 Port2 3.16e-11
L14 N13 Port2 4.12e-11
R14 N13 Port2 2.24e+00
.ENDS GRM21BR60G107ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+01[uF]/4[V]
* Murata P/N :GRM21BR60G476ME01
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR60G476ME01 Port1 Port2
C01 Port1 N01 3.87e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.38e-10
R03 N02 N03 1.61e-03
C04 N03 N04 2.31e-03
R04 N03 N04 1.84e+00
C05 N04 N05 2.93e-03
R05 N04 N05 1.90e-01
C06 N05 N06 2.01e-03
R06 N05 N06 3.63e-02
C07 N06 N07 1.97e-03
R07 N06 N07 2.71e-03
L08 N07 N08 2.21e-11
R08 N07 N08 4.46e-02
L09 N08 N09 6.25e-11
R09 N08 N09 1.85e-02
L10 N09 N10 3.76e-10
R10 N09 N10 9.31e-03
C11 N10 N11 1.14e-04
L11 N10 N11 9.13e-11
R11 N10 N11 1.58e-03
C12 N11 N12 6.77e-05
L12 N11 N12 8.12e-11
R12 N11 N12 1.81e-03
C13 N12 N13 3.69e-11
L13 N12 N13 4.60e-11
R13 N12 N13 2.07e+00
C14 N13 Port2 2.45e-12
L14 N13 Port2 8.30e-11
R14 N13 Port2 1.95e+01
.ENDS GRM21BR60G476ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM21BR60J106KE19
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR60J106KE19 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BR60J106KE19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM21BR60J106ME19
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR60J106ME19 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BR60J106ME19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+02[uF]/6.3[V]
* Murata P/N :GRM21BR60J107ME15
* Property : C = 1.00e+02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR60J107ME15 Port1 Port2
C01 Port1 N01 7.31e-05
R01 Port1 N01 5.00e+05
L02 N01 N02 1.95e-10
R03 N02 N03 1.33e-03
C04 N03 N04 4.16e-03
R04 N03 N04 8.33e-01
C05 N04 N05 5.06e-03
R05 N04 N05 6.43e-02
C06 N05 N06 4.91e-03
R06 N05 N06 1.09e-02
C07 N06 N07 8.50e-03
R07 N06 N07 5.04e-04
L08 N07 N08 1.53e-11
R08 N07 N08 6.08e-02
L09 N08 N09 2.67e-11
R09 N08 N09 2.12e-02
L10 N09 N10 7.82e-11
R10 N09 N10 1.23e-02
L11 N10 N11 4.17e-10
R11 N10 N11 6.65e-03
C12 N11 N12 1.73e-04
L12 N11 N12 1.28e-10
R12 N11 N12 1.08e-03
C13 N12 N13 1.53e-04
L13 N12 N13 8.20e-11
R13 N12 N13 8.47e-04
C14 N13 Port2 3.16e-11
L14 N13 Port2 4.12e-11
R14 N13 Port2 2.24e+00
.ENDS GRM21BR60J107ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRM21BR60J225KA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR60J225KA01 Port1 Port2
C01 Port1 N01 2.18e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 9.47e-11
R03 N02 N03 3.18e-03
C04 N03 N04 8.47e-05
R04 N03 N04 7.89e+01
C05 N04 N05 2.42e-04
R05 N04 N05 1.65e+00
C06 N05 N06 2.11e-04
R06 N05 N06 1.89e-01
C07 N06 N07 2.02e-04
R07 N06 N07 2.01e-02
C08 N07 N08 1.83e-04
R08 N07 N08 3.15e-03
L09 N08 N09 2.47e-11
R09 N08 N09 2.97e-02
L10 N09 N10 2.39e-10
R10 N09 N10 2.71e-02
C11 N10 N11 6.04e-06
L11 N10 N11 6.28e-11
R11 N10 N11 1.18e-02
C12 N11 N12 4.07e-06
L12 N11 N12 4.37e-11
R12 N11 N12 1.03e-02
C13 N12 N13 8.01e-12
L13 N12 N13 8.49e-11
R13 N12 N13 1.04e+01
C14 N13 Port2 2.97e-12
L14 N13 Port2 1.02e-10
R14 N13 Port2 2.55e+01
.ENDS GRM21BR60J225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRM21BR60J226ME39
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR60J226ME39 Port1 Port2
C01 Port1 N01 1.41e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.44e-10
R03 N02 N03 2.43e-03
C04 N03 N04 2.83e-04
R04 N03 N04 2.01e+01
C05 N04 N05 3.85e-04
R05 N04 N05 1.39e+00
C06 N05 N06 3.52e-04
R06 N05 N06 1.52e-01
C07 N06 N07 2.64e-04
R07 N06 N07 1.93e-02
C08 N07 N08 3.46e-04
R08 N07 N08 1.96e-03
L09 N08 N09 1.53e-11
R09 N08 N09 8.38e-02
L10 N09 N10 4.59e-11
R10 N09 N10 2.50e-02
L11 N10 N11 3.75e-10
R11 N10 N11 1.39e-02
C12 N11 N12 3.43e-05
L12 N11 N12 7.23e-11
R12 N11 N12 3.39e-03
C13 N12 N13 7.50e-05
L13 N12 N13 1.79e-11
R13 N12 N13 2.21e-03
C14 N13 N14 1.45e-11
L14 N13 N14 5.81e-11
R14 N13 N14 7.85e+00
C15 N14 Port2 8.35e-12
L15 N14 Port2 3.97e-11
R15 N14 Port2 5.40e+00
.ENDS GRM21BR60J226ME39
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRM21BR60J475KA11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR60J475KA11 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.72e-10
R03 N02 N03 3.96e-03
C04 N03 N04 4.93e-05
R04 N03 N04 1.13e+02
C05 N04 N05 9.27e-05
R05 N04 N05 3.89e+00
C06 N05 N06 8.77e-05
R06 N05 N06 4.03e-01
C07 N06 N07 6.58e-05
R07 N06 N07 5.09e-02
C08 N07 N08 6.31e-05
R08 N07 N08 5.54e-03
L09 N08 N09 9.24e-12
R09 N08 N09 5.25e-02
L10 N09 N10 2.82e-11
R10 N09 N10 2.91e-02
L11 N10 N11 2.89e-10
R11 N10 N11 2.35e-02
C12 N11 N12 9.87e-06
L12 N11 N12 5.10e-11
R12 N11 N12 8.09e-03
C13 N12 N13 9.42e-06
L13 N12 N13 2.60e-11
R13 N12 N13 6.28e-03
C14 N13 N14 1.16e-11
L14 N13 N14 5.80e-11
R14 N13 N14 7.91e+00
C15 N14 Port2 3.04e-11
L15 N14 Port2 1.41e-11
R15 N14 Port2 2.76e+00
.ENDS GRM21BR60J475KA11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRM21BR60J475MA11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR60J475MA11 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.72e-10
R03 N02 N03 3.96e-03
C04 N03 N04 4.93e-05
R04 N03 N04 1.13e+02
C05 N04 N05 9.27e-05
R05 N04 N05 3.89e+00
C06 N05 N06 8.77e-05
R06 N05 N06 4.03e-01
C07 N06 N07 6.58e-05
R07 N06 N07 5.09e-02
C08 N07 N08 6.31e-05
R08 N07 N08 5.54e-03
L09 N08 N09 9.24e-12
R09 N08 N09 5.25e-02
L10 N09 N10 2.82e-11
R10 N09 N10 2.91e-02
L11 N10 N11 2.89e-10
R11 N10 N11 2.35e-02
C12 N11 N12 9.87e-06
L12 N11 N12 5.10e-11
R12 N11 N12 8.09e-03
C13 N12 N13 9.42e-06
L13 N12 N13 2.60e-11
R13 N12 N13 6.28e-03
C14 N13 N14 1.16e-11
L14 N13 N14 5.80e-11
R14 N13 N14 7.91e+00
C15 N14 Port2 3.04e-11
L15 N14 Port2 1.41e-11
R15 N14 Port2 2.76e+00
.ENDS GRM21BR60J475MA11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRM21BR60J476ME01
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR60J476ME01 Port1 Port2
C01 Port1 N01 3.87e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.38e-10
R03 N02 N03 1.61e-03
C04 N03 N04 2.31e-03
R04 N03 N04 1.84e+00
C05 N04 N05 2.93e-03
R05 N04 N05 1.90e-01
C06 N05 N06 2.01e-03
R06 N05 N06 3.63e-02
C07 N06 N07 1.97e-03
R07 N06 N07 2.71e-03
L08 N07 N08 2.21e-11
R08 N07 N08 4.46e-02
L09 N08 N09 6.25e-11
R09 N08 N09 1.85e-02
L10 N09 N10 3.76e-10
R10 N09 N10 9.31e-03
C11 N10 N11 1.14e-04
L11 N10 N11 9.13e-11
R11 N10 N11 1.58e-03
C12 N11 N12 6.77e-05
L12 N11 N12 8.12e-11
R12 N11 N12 1.81e-03
C13 N12 N13 3.69e-11
L13 N12 N13 4.60e-11
R13 N12 N13 2.07e+00
C14 N13 Port2 2.45e-12
L14 N13 Port2 8.30e-11
R14 N13 Port2 1.95e+01
.ENDS GRM21BR60J476ME01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRM21BR60J476ME11
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR60J476ME11 Port1 Port2
C01 Port1 N01 3.80e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.67e-10
R03 N02 N03 2.37e-03
C04 N03 N04 2.18e-03
R04 N03 N04 2.13e+00
C05 N04 N05 2.70e-03
R05 N04 N05 2.25e-01
C06 N05 N06 2.84e-03
R06 N05 N06 3.03e-02
C07 N06 N07 3.55e-03
R07 N06 N07 2.25e-03
L08 N07 N08 2.31e-11
R08 N07 N08 8.12e-02
L09 N08 N09 6.34e-11
R09 N08 N09 2.18e-02
L10 N09 N10 3.46e-10
R10 N09 N10 9.82e-03
C11 N10 N11 9.08e-05
L11 N10 N11 9.80e-11
R11 N10 N11 2.32e-03
C12 N11 N12 4.32e-05
L12 N11 N12 9.04e-11
R12 N11 N12 2.65e-03
C13 N12 N13 1.13e-11
L13 N12 N13 4.13e-11
R13 N12 N13 7.83e+00
C14 N13 Port2 9.83e-12
L14 N13 Port2 3.48e-11
R14 N13 Port2 1.11e+01
.ENDS GRM21BR60J476ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRM21BR61A105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61A105KA01 Port1 Port2
C01 Port1 N01 9.33e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.89e-10
R03 N02 N03 4.90e-03
C04 N03 N04 1.81e-04
R04 N03 N04 6.47e+00
C05 N04 N05 1.23e-04
R05 N04 N05 7.97e-01
C06 N05 N06 1.13e-04
R06 N05 N06 9.92e-02
C07 N06 N07 7.87e-05
R07 N06 N07 1.33e-02
L08 N07 N08 1.81e-11
R08 N07 N08 5.44e-02
L09 N08 N09 1.88e-10
R09 N08 N09 3.80e-02
C10 N09 N10 3.05e-06
L10 N09 N10 5.20e-11
R10 N09 N10 1.67e-02
C11 N10 N11 1.74e-06
L11 N10 N11 4.23e-11
R11 N10 N11 1.75e-02
C12 N11 N12 8.19e-12
L12 N11 N12 9.37e-11
R12 N11 N12 1.03e+01
C13 N12 Port2 5.87e-12
L13 N12 Port2 5.67e-11
R13 N12 Port2 1.96e+01
.ENDS GRM21BR61A105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM21BR61A106KE19
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61A106KE19 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BR61A106KE19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM21BR61A106ME19
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61A106ME19 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BR61A106ME19
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRM21BR61A225KA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61A225KA01 Port1 Port2
C01 Port1 N01 2.18e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 9.47e-11
R03 N02 N03 3.18e-03
C04 N03 N04 8.47e-05
R04 N03 N04 7.89e+01
C05 N04 N05 2.42e-04
R05 N04 N05 1.65e+00
C06 N05 N06 2.11e-04
R06 N05 N06 1.89e-01
C07 N06 N07 2.02e-04
R07 N06 N07 2.01e-02
C08 N07 N08 1.83e-04
R08 N07 N08 3.15e-03
L09 N08 N09 2.47e-11
R09 N08 N09 2.97e-02
L10 N09 N10 2.39e-10
R10 N09 N10 2.71e-02
C11 N10 N11 6.04e-06
L11 N10 N11 6.28e-11
R11 N10 N11 1.18e-02
C12 N11 N12 4.07e-06
L12 N11 N12 4.37e-11
R12 N11 N12 1.03e-02
C13 N12 N13 8.01e-12
L13 N12 N13 8.49e-11
R13 N12 N13 1.04e+01
C14 N13 Port2 2.97e-12
L14 N13 Port2 1.02e-10
R14 N13 Port2 2.55e+01
.ENDS GRM21BR61A225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRM21BR61A225MA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61A225MA01 Port1 Port2
C01 Port1 N01 2.18e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 9.47e-11
R03 N02 N03 3.18e-03
C04 N03 N04 8.47e-05
R04 N03 N04 7.89e+01
C05 N04 N05 2.42e-04
R05 N04 N05 1.65e+00
C06 N05 N06 2.11e-04
R06 N05 N06 1.89e-01
C07 N06 N07 2.02e-04
R07 N06 N07 2.01e-02
C08 N07 N08 1.83e-04
R08 N07 N08 3.15e-03
L09 N08 N09 2.47e-11
R09 N08 N09 2.97e-02
L10 N09 N10 2.39e-10
R10 N09 N10 2.71e-02
C11 N10 N11 6.04e-06
L11 N10 N11 6.28e-11
R11 N10 N11 1.18e-02
C12 N11 N12 4.07e-06
L12 N11 N12 4.37e-11
R12 N11 N12 1.03e-02
C13 N12 N13 8.01e-12
L13 N12 N13 8.49e-11
R13 N12 N13 1.04e+01
C14 N13 Port2 2.97e-12
L14 N13 Port2 1.02e-10
R14 N13 Port2 2.55e+01
.ENDS GRM21BR61A225MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRM21BR61A226ME44
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61A226ME44 Port1 Port2
C01 Port1 N01 1.70e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.60e-10
R03 N02 N03 2.11e-03
C04 N03 N04 6.67e-04
R04 N03 N04 7.95e+00
C05 N04 N05 7.65e-04
R05 N04 N05 7.74e-01
C06 N05 N06 7.03e-04
R06 N05 N06 9.99e-02
C07 N06 N07 6.45e-04
R07 N06 N07 1.24e-02
C08 N07 N08 6.19e-04
R08 N07 N08 1.97e-03
L09 N08 N09 1.62e-11
R09 N08 N09 5.44e-02
L10 N09 N10 3.66e-11
R10 N09 N10 2.02e-02
L11 N10 N11 3.37e-10
R11 N10 N11 1.34e-02
C12 N11 N12 5.83e-05
L12 N11 N12 6.41e-11
R12 N11 N12 3.35e-03
C13 N12 N13 2.26e-05
L13 N12 N13 8.31e-11
R13 N12 N13 3.61e-03
C14 N13 Port2 4.77e-12
L14 N13 Port2 8.46e-11
R14 N13 Port2 1.47e+01
.ENDS GRM21BR61A226ME44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRM21BR61A226ME51
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61A226ME51 Port1 Port2
C01 Port1 N01 1.39e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.30e-10
R03 N02 N03 2.82e-03
C04 N03 N04 2.65e-04
R04 N03 N04 2.09e+01
C05 N04 N05 3.55e-04
R05 N04 N05 1.46e+00
C06 N05 N06 3.16e-04
R06 N05 N06 1.66e-01
C07 N06 N07 3.15e-04
R07 N06 N07 1.69e-02
C08 N07 N08 3.14e-04
R08 N07 N08 3.37e-03
L09 N08 N09 1.24e-11
R09 N08 N09 7.31e-02
L10 N09 N10 4.63e-11
R10 N09 N10 2.87e-02
L11 N10 N11 3.31e-10
R11 N10 N11 1.45e-02
C12 N11 N12 3.75e-05
L12 N11 N12 6.73e-11
R12 N11 N12 2.86e-03
C13 N12 N13 2.57e-05
L13 N12 N13 4.91e-11
R13 N12 N13 2.48e-03
C14 N13 N14 1.19e-11
L14 N13 N14 6.42e-11
R14 N13 N14 8.47e+00
C15 N14 Port2 6.03e-12
L15 N14 Port2 4.85e-11
R15 N14 Port2 2.31e+01
.ENDS GRM21BR61A226ME51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM21BR61A475KA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61A475KA73 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.72e-10
R03 N02 N03 3.96e-03
C04 N03 N04 4.93e-05
R04 N03 N04 1.13e+02
C05 N04 N05 9.27e-05
R05 N04 N05 3.89e+00
C06 N05 N06 8.77e-05
R06 N05 N06 4.03e-01
C07 N06 N07 6.58e-05
R07 N06 N07 5.09e-02
C08 N07 N08 6.31e-05
R08 N07 N08 5.54e-03
L09 N08 N09 9.24e-12
R09 N08 N09 5.25e-02
L10 N09 N10 2.82e-11
R10 N09 N10 2.91e-02
L11 N10 N11 2.89e-10
R11 N10 N11 2.35e-02
C12 N11 N12 9.87e-06
L12 N11 N12 5.10e-11
R12 N11 N12 8.09e-03
C13 N12 N13 9.42e-06
L13 N12 N13 2.60e-11
R13 N12 N13 6.28e-03
C14 N13 N14 1.16e-11
L14 N13 N14 5.80e-11
R14 N13 N14 7.91e+00
C15 N14 Port2 3.04e-11
L15 N14 Port2 1.41e-11
R15 N14 Port2 2.76e+00
.ENDS GRM21BR61A475KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM21BR61A475MA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61A475MA73 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.72e-10
R03 N02 N03 3.96e-03
C04 N03 N04 4.93e-05
R04 N03 N04 1.13e+02
C05 N04 N05 9.27e-05
R05 N04 N05 3.89e+00
C06 N05 N06 8.77e-05
R06 N05 N06 4.03e-01
C07 N06 N07 6.58e-05
R07 N06 N07 5.09e-02
C08 N07 N08 6.31e-05
R08 N07 N08 5.54e-03
L09 N08 N09 9.24e-12
R09 N08 N09 5.25e-02
L10 N09 N10 2.82e-11
R10 N09 N10 2.91e-02
L11 N10 N11 2.89e-10
R11 N10 N11 2.35e-02
C12 N11 N12 9.87e-06
L12 N11 N12 5.10e-11
R12 N11 N12 8.09e-03
C13 N12 N13 9.42e-06
L13 N12 N13 2.60e-11
R13 N12 N13 6.28e-03
C14 N13 N14 1.16e-11
L14 N13 N14 5.80e-11
R14 N13 N14 7.91e+00
C15 N14 Port2 3.04e-11
L15 N14 Port2 1.41e-11
R15 N14 Port2 2.76e+00
.ENDS GRM21BR61A475MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+01[uF]/10[V]
* Murata P/N :GRM21BR61A476ME15
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61A476ME15 Port1 Port2
C01 Port1 N01 3.80e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.67e-10
R03 N02 N03 2.37e-03
C04 N03 N04 2.18e-03
R04 N03 N04 2.13e+00
C05 N04 N05 2.70e-03
R05 N04 N05 2.25e-01
C06 N05 N06 2.84e-03
R06 N05 N06 3.03e-02
C07 N06 N07 3.55e-03
R07 N06 N07 2.25e-03
L08 N07 N08 2.31e-11
R08 N07 N08 8.12e-02
L09 N08 N09 6.34e-11
R09 N08 N09 2.18e-02
L10 N09 N10 3.46e-10
R10 N09 N10 9.82e-03
C11 N10 N11 9.08e-05
L11 N10 N11 9.80e-11
R11 N10 N11 2.32e-03
C12 N11 N12 4.32e-05
L12 N11 N12 9.04e-11
R12 N11 N12 2.65e-03
C13 N12 N13 1.13e-11
L13 N12 N13 4.13e-11
R13 N12 N13 7.83e+00
C14 N13 Port2 9.83e-12
L14 N13 Port2 3.48e-11
R14 N13 Port2 1.11e+01
.ENDS GRM21BR61A476ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRM21BR61C105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61C105KA01 Port1 Port2
C01 Port1 N01 9.33e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.89e-10
R03 N02 N03 4.90e-03
C04 N03 N04 1.81e-04
R04 N03 N04 6.47e+00
C05 N04 N05 1.23e-04
R05 N04 N05 7.97e-01
C06 N05 N06 1.13e-04
R06 N05 N06 9.92e-02
C07 N06 N07 7.87e-05
R07 N06 N07 1.33e-02
L08 N07 N08 1.81e-11
R08 N07 N08 5.44e-02
L09 N08 N09 1.88e-10
R09 N08 N09 3.80e-02
C10 N09 N10 3.05e-06
L10 N09 N10 5.20e-11
R10 N09 N10 1.67e-02
C11 N10 N11 1.74e-06
L11 N10 N11 4.23e-11
R11 N10 N11 1.75e-02
C12 N11 N12 8.19e-12
L12 N11 N12 9.37e-11
R12 N11 N12 1.03e+01
C13 N12 Port2 5.87e-12
L13 N12 Port2 5.67e-11
R13 N12 Port2 1.96e+01
.ENDS GRM21BR61C105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM21BR61C106KE15
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61C106KE15 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BR61C106KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GRM21BR61C106ME15
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61C106ME15 Port1 Port2
C01 Port1 N01 8.64e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.11e-10
R03 N02 N03 2.18e-03
C04 N03 N04 3.37e-04
R04 N03 N04 1.69e+01
C05 N04 N05 5.14e-04
R05 N04 N05 1.18e+00
C06 N05 N06 5.77e-04
R06 N05 N06 9.23e-02
C07 N06 N07 5.77e-04
R07 N06 N07 8.53e-03
C08 N07 N08 5.42e-04
R08 N07 N08 1.47e-03
L09 N08 N09 9.28e-12
R09 N08 N09 1.18e-01
L10 N09 N10 3.87e-11
R10 N09 N10 2.81e-02
L11 N10 N11 3.38e-10
R11 N10 N11 1.46e-02
C12 N11 N12 2.14e-05
L12 N11 N12 6.85e-11
R12 N11 N12 4.17e-03
C13 N12 N13 3.41e-05
L13 N12 N13 2.30e-11
R13 N12 N13 3.16e-03
C14 N13 N14 6.72e-12
L14 N13 N14 8.81e-11
R14 N13 N14 1.10e+01
C15 N14 Port2 5.20e-12
L15 N14 Port2 6.20e-11
R15 N14 Port2 1.92e+01
.ENDS GRM21BR61C106ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRM21BR61C225KA88
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61C225KA88 Port1 Port2
C01 Port1 N01 1.65e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 7.14e-11
R03 N02 N03 5.67e-03
C04 N03 N04 2.63e-05
R04 N03 N04 2.01e+02
C05 N04 N05 4.26e-05
R05 N04 N05 7.12e+00
C06 N05 N06 3.99e-05
R06 N05 N06 6.91e-01
C07 N06 N07 3.03e-05
R07 N06 N07 9.36e-02
C08 N07 N08 2.45e-05
R08 N07 N08 1.11e-02
L09 N08 N09 1.74e-11
R09 N08 N09 2.85e-02
L10 N09 N10 1.81e-10
R10 N09 N10 2.66e-02
C11 N10 N11 6.55e-06
L11 N10 N11 2.93e-11
R11 N10 N11 7.55e-03
C12 N11 N12 2.70e-06
L12 N11 N12 3.14e-11
R12 N11 N12 1.00e-02
C13 N12 N13 7.79e-12
L13 N12 N13 1.48e-10
R13 N12 N13 2.12e+01
C14 N13 Port2 2.08e-12
L14 N13 Port2 1.84e-10
R14 N13 Port2 3.72e+01
.ENDS GRM21BR61C225KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GRM21BR61C226ME44
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61C226ME44 Port1 Port2
C01 Port1 N01 1.70e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.60e-10
R03 N02 N03 2.11e-03
C04 N03 N04 6.67e-04
R04 N03 N04 7.95e+00
C05 N04 N05 7.65e-04
R05 N04 N05 7.74e-01
C06 N05 N06 7.03e-04
R06 N05 N06 9.99e-02
C07 N06 N07 6.45e-04
R07 N06 N07 1.24e-02
C08 N07 N08 6.19e-04
R08 N07 N08 1.97e-03
L09 N08 N09 1.62e-11
R09 N08 N09 5.44e-02
L10 N09 N10 3.66e-11
R10 N09 N10 2.02e-02
L11 N10 N11 3.37e-10
R11 N10 N11 1.34e-02
C12 N11 N12 5.83e-05
L12 N11 N12 6.41e-11
R12 N11 N12 3.35e-03
C13 N12 N13 2.26e-05
L13 N12 N13 8.31e-11
R13 N12 N13 3.61e-03
C14 N13 Port2 4.77e-12
L14 N13 Port2 8.46e-11
R14 N13 Port2 1.47e+01
.ENDS GRM21BR61C226ME44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GRM21BR61C474KA01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61C474KA01 Port1 Port2
C01 Port1 N01 4.65e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 2.35e-10
R03 N02 N03 5.70e-03
C04 N03 N04 1.11e-04
R04 N03 N04 2.48e+01
C05 N04 N05 9.89e-05
R05 N04 N05 8.41e+00
C06 N05 N06 9.49e-05
R06 N05 N06 1.65e+00
C07 N06 N07 9.10e-05
R07 N06 N07 3.68e-01
C08 N07 N08 7.14e-05
R08 N07 N08 8.86e-02
C09 N08 N09 4.69e-05
R09 N08 N09 1.75e-02
L10 N09 N10 1.35e-11
R10 N09 N10 5.79e-02
L11 N10 N11 1.18e-10
R11 N10 N11 2.82e-02
L12 N11 N12 1.06e-10
R12 N11 N12 2.78e-02
C13 N12 N13 2.32e-06
L13 N12 N13 3.53e-11
R13 N12 N13 2.70e-02
C14 N13 N14 7.90e-07
L14 N13 N14 5.02e-11
R14 N13 N14 2.63e-02
C15 N14 Port2 9.96e-12
L15 N14 Port2 8.98e-11
R15 N14 Port2 7.97e+00
.ENDS GRM21BR61C474KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM21BR61C475KA88
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61C475KA88 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRM21BR61C475KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/20[V]
* Murata P/N :GRM21BR61D106KE15
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61D106KE15 Port1 Port2
C01 Port1 N01 7.37e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.65e-10
R03 N02 N03 3.67e-03
C04 N03 N04 1.78e-04
R04 N03 N04 2.87e+01
C05 N04 N05 2.15e-04
R05 N04 N05 2.07e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.95e-01
C07 N06 N07 1.63e-04
R07 N06 N07 4.31e-02
C08 N07 N08 1.24e-04
R08 N07 N08 7.12e-03
L09 N08 N09 1.88e-11
R09 N08 N09 1.48e-01
L10 N09 N10 3.83e-11
R10 N09 N10 2.67e-02
L11 N10 N11 2.60e-10
R11 N10 N11 1.59e-02
C12 N11 N12 2.22e-05
L12 N11 N12 5.51e-11
R12 N11 N12 4.65e-03
C13 N12 N13 1.44e-05
L13 N12 N13 4.28e-11
R13 N12 N13 4.55e-03
C14 N13 N14 9.14e-12
L14 N13 N14 6.16e-11
R14 N13 N14 1.16e+01
C15 N14 Port2 7.96e-12
L15 N14 Port2 4.00e-11
R15 N14 Port2 2.00e+01
.ENDS GRM21BR61D106KE15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/20[V]
* Murata P/N :GRM21BR61D106ME15
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61D106ME15 Port1 Port2
C01 Port1 N01 7.37e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.65e-10
R03 N02 N03 3.67e-03
C04 N03 N04 1.78e-04
R04 N03 N04 2.87e+01
C05 N04 N05 2.15e-04
R05 N04 N05 2.07e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.95e-01
C07 N06 N07 1.63e-04
R07 N06 N07 4.31e-02
C08 N07 N08 1.24e-04
R08 N07 N08 7.12e-03
L09 N08 N09 1.88e-11
R09 N08 N09 1.48e-01
L10 N09 N10 3.83e-11
R10 N09 N10 2.67e-02
L11 N10 N11 2.60e-10
R11 N10 N11 1.59e-02
C12 N11 N12 2.22e-05
L12 N11 N12 5.51e-11
R12 N11 N12 4.65e-03
C13 N12 N13 1.44e-05
L13 N12 N13 4.28e-11
R13 N12 N13 4.55e-03
C14 N13 N14 9.14e-12
L14 N13 N14 6.16e-11
R14 N13 N14 1.16e+01
C15 N14 Port2 7.96e-12
L15 N14 Port2 4.00e-11
R15 N14 Port2 2.00e+01
.ENDS GRM21BR61D106ME15
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM21BR61E106KA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61E106KA73 Port1 Port2
C01 Port1 N01 6.20e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.12e-10
R03 N02 N03 3.36e-03
C04 N03 N04 1.83e-04
R04 N03 N04 1.39e+01
C05 N04 N05 2.37e-04
R05 N04 N05 1.12e+00
C06 N05 N06 2.37e-04
R06 N05 N06 1.49e-01
C07 N06 N07 2.04e-04
R07 N06 N07 2.32e-02
C08 N07 N08 1.99e-04
R08 N07 N08 4.48e-03
L09 N08 N09 1.70e-11
R09 N08 N09 1.04e-01
L10 N09 N10 3.26e-11
R10 N09 N10 2.48e-02
L11 N10 N11 2.49e-10
R11 N10 N11 1.86e-02
C12 N11 N12 1.84e-05
L12 N11 N12 6.20e-11
R12 N11 N12 4.79e-03
C13 N12 N13 1.22e-05
L13 N12 N13 4.65e-11
R13 N12 N13 3.76e-03
C14 N13 Port2 8.91e-12
L14 N13 Port2 7.96e-11
R14 N13 Port2 1.34e+01
.ENDS GRM21BR61E106KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRM21BR61E106MA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61E106MA73 Port1 Port2
C01 Port1 N01 6.20e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.12e-10
R03 N02 N03 3.36e-03
C04 N03 N04 1.83e-04
R04 N03 N04 1.39e+01
C05 N04 N05 2.37e-04
R05 N04 N05 1.12e+00
C06 N05 N06 2.37e-04
R06 N05 N06 1.49e-01
C07 N06 N07 2.04e-04
R07 N06 N07 2.32e-02
C08 N07 N08 1.99e-04
R08 N07 N08 4.48e-03
L09 N08 N09 1.70e-11
R09 N08 N09 1.04e-01
L10 N09 N10 3.26e-11
R10 N09 N10 2.48e-02
L11 N10 N11 2.49e-10
R11 N10 N11 1.86e-02
C12 N11 N12 1.84e-05
L12 N11 N12 6.20e-11
R12 N11 N12 4.79e-03
C13 N12 N13 1.22e-05
L13 N12 N13 4.65e-11
R13 N12 N13 3.76e-03
C14 N13 Port2 8.91e-12
L14 N13 Port2 7.96e-11
R14 N13 Port2 1.34e+01
.ENDS GRM21BR61E106MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM21BR61E225KA12
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61E225KA12 Port1 Port2
C01 Port1 N01 1.65e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 7.14e-11
R03 N02 N03 5.67e-03
C04 N03 N04 2.63e-05
R04 N03 N04 2.01e+02
C05 N04 N05 4.26e-05
R05 N04 N05 7.12e+00
C06 N05 N06 3.99e-05
R06 N05 N06 6.91e-01
C07 N06 N07 3.03e-05
R07 N06 N07 9.36e-02
C08 N07 N08 2.45e-05
R08 N07 N08 1.11e-02
L09 N08 N09 1.74e-11
R09 N08 N09 2.85e-02
L10 N09 N10 1.81e-10
R10 N09 N10 2.66e-02
C11 N10 N11 6.55e-06
L11 N10 N11 2.93e-11
R11 N10 N11 7.55e-03
C12 N11 N12 2.70e-06
L12 N11 N12 3.14e-11
R12 N11 N12 1.00e-02
C13 N12 N13 7.79e-12
L13 N12 N13 1.48e-10
R13 N12 N13 2.12e+01
C14 N13 Port2 2.08e-12
L14 N13 Port2 1.84e-10
R14 N13 Port2 3.72e+01
.ENDS GRM21BR61E225KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/25[V]
* Murata P/N :GRM21BR61E226ME44
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61E226ME44 Port1 Port2
C01 Port1 N01 1.70e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.60e-10
R03 N02 N03 2.11e-03
C04 N03 N04 6.67e-04
R04 N03 N04 7.95e+00
C05 N04 N05 7.65e-04
R05 N04 N05 7.74e-01
C06 N05 N06 7.03e-04
R06 N05 N06 9.99e-02
C07 N06 N07 6.45e-04
R07 N06 N07 1.24e-02
C08 N07 N08 6.19e-04
R08 N07 N08 1.97e-03
L09 N08 N09 1.62e-11
R09 N08 N09 5.44e-02
L10 N09 N10 3.66e-11
R10 N09 N10 2.02e-02
L11 N10 N11 3.37e-10
R11 N10 N11 1.34e-02
C12 N11 N12 5.83e-05
L12 N11 N12 6.41e-11
R12 N11 N12 3.35e-03
C13 N12 N13 2.26e-05
L13 N12 N13 8.31e-11
R13 N12 N13 3.61e-03
C14 N13 Port2 4.77e-12
L14 N13 Port2 8.46e-11
R14 N13 Port2 1.47e+01
.ENDS GRM21BR61E226ME44
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRM21BR61E475KA12
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61E475KA12 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRM21BR61E475KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRM21BR61E475MA12
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61E475MA12 Port1 Port2
C01 Port1 N01 3.42e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-10
R03 N02 N03 3.77e-03
C04 N03 N04 7.12e-05
R04 N03 N04 7.45e+01
C05 N04 N05 1.04e-04
R05 N04 N05 3.79e+00
C06 N05 N06 8.28e-05
R06 N05 N06 4.51e-01
C07 N06 N07 6.88e-05
R07 N06 N07 5.04e-02
C08 N07 N08 6.10e-05
R08 N07 N08 6.43e-03
L09 N08 N09 9.83e-12
R09 N08 N09 7.88e-02
L10 N09 N10 2.41e-11
R10 N09 N10 3.07e-02
L11 N10 N11 2.71e-10
R11 N10 N11 2.46e-02
C12 N11 N12 9.33e-06
L12 N11 N12 5.46e-11
R12 N11 N12 7.49e-03
C13 N12 N13 6.08e-06
L13 N12 N13 4.10e-11
R13 N12 N13 6.62e-03
C14 N13 N14 1.37e-11
L14 N13 N14 4.94e-11
R14 N13 N14 8.08e+00
C15 N14 Port2 3.66e-12
L15 N14 Port2 7.78e-11
R15 N14 Port2 2.82e+01
.ENDS GRM21BR61E475MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRM21BR61H105KA12
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61H105KA12 Port1 Port2
C01 Port1 N01 9.39e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.89e-10
R03 N02 N03 4.20e-03
C04 N03 N04 2.65e-04
R04 N03 N04 1.50e+01
C05 N04 N05 3.96e-04
R05 N04 N05 1.66e+00
C06 N05 N06 2.76e-04
R06 N05 N06 4.58e-01
C07 N06 N07 1.89e-04
R07 N06 N07 9.91e-02
C08 N07 N08 1.52e-04
R08 N07 N08 1.58e-02
C09 N08 N09 3.22e-04
R09 N08 N09 1.94e-03
L10 N09 N10 2.38e-11
R10 N09 N10 7.83e-02
L11 N10 N11 2.31e-10
R11 N10 N11 3.87e-02
C12 N11 N12 3.52e-06
L12 N11 N12 4.72e-11
R12 N11 N12 1.52e-02
C13 N12 N13 2.26e-06
L13 N12 N13 3.52e-11
R13 N12 N13 1.51e-02
C14 N13 N14 1.80e-11
L14 N13 N14 6.17e-11
R14 N13 N14 6.01e+00
C15 N14 Port2 1.36e-11
L15 N14 Port2 2.94e-11
R15 N14 Port2 2.95e+00
.ENDS GRM21BR61H105KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/50[V]
* Murata P/N :GRM21BR61H106KE43
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61H106KE43 Port1 Port2
C01 Port1 N01 7.54e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.16e-10
R03 N02 N03 2.62e-03
C04 N03 N04 3.13e-04
R04 N03 N04 4.72e+00
C05 N04 N05 4.07e-04
R05 N04 N05 4.58e-01
C06 N05 N06 4.05e-04
R06 N05 N06 7.18e-02
C07 N06 N07 3.75e-04
R07 N06 N07 1.28e-02
C08 N07 N08 3.35e-04
R08 N07 N08 3.10e-03
L09 N08 N09 1.65e-11
R09 N08 N09 5.59e-02
L10 N09 N10 2.33e-10
R10 N09 N10 1.62e-02
L11 N10 N11 2.29e-11
R11 N10 N11 1.30e-02
C12 N11 N12 2.05e-05
L12 N11 N12 7.34e-11
R12 N11 N12 6.15e-03
C13 N12 N13 9.27e-06
L13 N12 N13 7.87e-11
R13 N12 N13 7.13e-03
C14 N13 N14 1.44e-11
L14 N13 N14 4.80e-11
R14 N13 N14 8.65e+00
C15 N14 Port2 8.95e-12
L15 N14 Port2 3.37e-11
R15 N14 Port2 1.11e+01
.ENDS GRM21BR61H106KE43
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/50[V]
* Murata P/N :GRM21BR61H106ME43
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61H106ME43 Port1 Port2
C01 Port1 N01 7.54e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.16e-10
R03 N02 N03 2.62e-03
C04 N03 N04 3.13e-04
R04 N03 N04 4.72e+00
C05 N04 N05 4.07e-04
R05 N04 N05 4.58e-01
C06 N05 N06 4.05e-04
R06 N05 N06 7.18e-02
C07 N06 N07 3.75e-04
R07 N06 N07 1.28e-02
C08 N07 N08 3.35e-04
R08 N07 N08 3.10e-03
L09 N08 N09 1.65e-11
R09 N08 N09 5.59e-02
L10 N09 N10 2.33e-10
R10 N09 N10 1.62e-02
L11 N10 N11 2.29e-11
R11 N10 N11 1.30e-02
C12 N11 N12 2.05e-05
L12 N11 N12 7.34e-11
R12 N11 N12 6.15e-03
C13 N12 N13 9.27e-06
L13 N12 N13 7.87e-11
R13 N12 N13 7.13e-03
C14 N13 N14 1.44e-11
L14 N13 N14 4.80e-11
R14 N13 N14 8.65e+00
C15 N14 Port2 8.95e-12
L15 N14 Port2 3.37e-11
R15 N14 Port2 1.11e+01
.ENDS GRM21BR61H106ME43
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRM21BR61H225KA73
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61H225KA73 Port1 Port2
C01 Port1 N01 1.75e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 9.23e-11
R03 N02 N03 6.12e-03
C04 N03 N04 1.55e-05
R04 N03 N04 3.66e+02
C05 N04 N05 4.23e-05
R05 N04 N05 6.79e+00
C06 N05 N06 3.83e-05
R06 N05 N06 7.63e-01
C07 N06 N07 2.95e-05
R07 N06 N07 9.81e-02
C08 N07 N08 2.58e-05
R08 N07 N08 1.11e-02
L09 N08 N09 2.40e-11
R09 N08 N09 3.47e-02
L10 N09 N10 1.48e-10
R10 N09 N10 2.44e-02
C11 N10 N11 5.56e-06
L11 N10 N11 3.52e-11
R11 N10 N11 7.95e-03
C12 N11 N12 1.79e-06
L12 N11 N12 5.26e-11
R12 N11 N12 1.09e-02
C13 N12 N13 1.18e-11
L13 N12 N13 1.11e-10
R13 N12 N13 1.74e+01
C14 N13 Port2 1.92e-12
L14 N13 Port2 1.93e-10
R14 N13 Port2 3.53e+01
.ENDS GRM21BR61H225KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRM21BR61H225MA73
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61H225MA73 Port1 Port2
C01 Port1 N01 1.75e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 9.23e-11
R03 N02 N03 6.12e-03
C04 N03 N04 1.55e-05
R04 N03 N04 3.66e+02
C05 N04 N05 4.23e-05
R05 N04 N05 6.79e+00
C06 N05 N06 3.83e-05
R06 N05 N06 7.63e-01
C07 N06 N07 2.95e-05
R07 N06 N07 9.81e-02
C08 N07 N08 2.58e-05
R08 N07 N08 1.11e-02
L09 N08 N09 2.40e-11
R09 N08 N09 3.47e-02
L10 N09 N10 1.48e-10
R10 N09 N10 2.44e-02
C11 N10 N11 5.56e-06
L11 N10 N11 3.52e-11
R11 N10 N11 7.95e-03
C12 N11 N12 1.79e-06
L12 N11 N12 5.26e-11
R12 N11 N12 1.09e-02
C13 N12 N13 1.18e-11
L13 N12 N13 1.11e-10
R13 N12 N13 1.74e+01
C14 N13 Port2 1.92e-12
L14 N13 Port2 1.93e-10
R14 N13 Port2 3.53e+01
.ENDS GRM21BR61H225MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRM21BR61H475KE51
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61H475KE51 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.04e-10
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 1.50e-11
L14 N13 N14 5.47e-11
R14 N13 N14 9.30e+00
C15 N14 Port2 1.96e-12
L15 N14 Port2 1.18e-10
R15 N14 Port2 2.13e+01
.ENDS GRM21BR61H475KE51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRM21BR61H475ME51
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR61H475ME51 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.04e-10
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 1.50e-11
L14 N13 N14 5.47e-11
R14 N13 N14 9.30e+00
C15 N14 Port2 1.96e-12
L15 N14 Port2 1.18e-10
R15 N14 Port2 2.13e+01
.ENDS GRM21BR61H475ME51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GRM21BR6YA106KE43
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR6YA106KE43 Port1 Port2
C01 Port1 N01 7.56e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.69e-10
R03 N02 N03 3.08e-03
C04 N03 N04 2.44e-04
R04 N03 N04 1.79e+01
C05 N04 N05 3.90e-04
R05 N04 N05 1.10e+00
C06 N05 N06 3.85e-04
R06 N05 N06 1.55e-01
C07 N06 N07 3.26e-04
R07 N06 N07 2.56e-02
C08 N07 N08 2.58e-04
R08 N07 N08 4.40e-03
L09 N08 N09 8.88e-12
R09 N08 N09 5.63e-02
L10 N09 N10 3.26e-11
R10 N09 N10 2.92e-02
L11 N10 N11 2.59e-10
R11 N10 N11 1.64e-02
C12 N11 N12 2.11e-05
L12 N11 N12 6.88e-11
R12 N11 N12 5.96e-03
C13 N12 N13 1.05e-05
L13 N12 N13 6.77e-11
R13 N12 N13 6.34e-03
C14 N13 N14 1.11e-11
L14 N13 N14 6.23e-11
R14 N13 N14 1.31e+01
C15 N14 Port2 5.04e-12
L15 N14 Port2 6.61e-11
R15 N14 Port2 1.81e+01
.ENDS GRM21BR6YA106KE43
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GRM21BR6YA106ME43
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR6YA106ME43 Port1 Port2
C01 Port1 N01 7.56e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.69e-10
R03 N02 N03 3.08e-03
C04 N03 N04 2.44e-04
R04 N03 N04 1.79e+01
C05 N04 N05 3.90e-04
R05 N04 N05 1.10e+00
C06 N05 N06 3.85e-04
R06 N05 N06 1.55e-01
C07 N06 N07 3.26e-04
R07 N06 N07 2.56e-02
C08 N07 N08 2.58e-04
R08 N07 N08 4.40e-03
L09 N08 N09 8.88e-12
R09 N08 N09 5.63e-02
L10 N09 N10 3.26e-11
R10 N09 N10 2.92e-02
L11 N10 N11 2.59e-10
R11 N10 N11 1.64e-02
C12 N11 N12 2.11e-05
L12 N11 N12 6.88e-11
R12 N11 N12 5.96e-03
C13 N12 N13 1.05e-05
L13 N12 N13 6.77e-11
R13 N12 N13 6.34e-03
C14 N13 N14 1.11e-11
L14 N13 N14 6.23e-11
R14 N13 N14 1.31e+01
C15 N14 Port2 5.04e-12
L15 N14 Port2 6.61e-11
R15 N14 Port2 1.81e+01
.ENDS GRM21BR6YA106ME43
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM21BR70J106KA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR70J106KA73 Port1 Port2
C01 Port1 N01 6.49e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.55e-10
R03 N02 N03 3.00e-03
C04 N03 N04 1.15e-04
R04 N03 N04 4.60e+01
C05 N04 N05 1.94e-04
R05 N04 N05 1.69e+00
C06 N05 N06 1.75e-04
R06 N05 N06 1.30e-01
C07 N06 N07 1.36e-04
R07 N06 N07 1.21e-02
C08 N07 N08 5.68e-04
R08 N07 N08 2.29e-04
L09 N08 N09 4.13e-11
R09 N08 N09 3.53e-02
L10 N09 N10 3.30e-10
R10 N09 N10 1.75e-02
C11 N10 N11 2.90e-05
L11 N10 N11 4.14e-11
R11 N10 N11 4.76e-03
C12 N11 N12 1.56e-05
L12 N11 N12 3.95e-11
R12 N11 N12 4.16e-03
C13 N12 Port2 6.42e-12
L13 N12 Port2 1.04e-10
R13 N12 Port2 1.01e+01
.ENDS GRM21BR70J106KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM21BR70J106KE76
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR70J106KE76 Port1 Port2
C01 Port1 N01 7.03e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.42e-10
R03 N02 N03 3.02e-03
C04 N03 N04 1.75e-04
R04 N03 N04 3.03e+01
C05 N04 N05 1.96e-04
R05 N04 N05 2.25e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.25e-01
C07 N06 N07 1.56e-04
R07 N06 N07 2.57e-02
C08 N07 N08 1.37e-04
R08 N07 N08 3.09e-03
L09 N08 N09 1.55e-11
R09 N08 N09 1.05e-01
L10 N09 N10 3.92e-11
R10 N09 N10 3.14e-02
L11 N10 N11 3.62e-10
R11 N10 N11 1.71e-02
C12 N11 N12 1.61e-05
L12 N11 N12 7.22e-11
R12 N11 N12 4.78e-03
C13 N12 N13 3.70e-05
L13 N12 N13 1.71e-11
R13 N12 N13 2.88e-03
C14 N13 N14 7.98e-12
L14 N13 N14 8.68e-11
R14 N13 N14 1.07e+01
C15 N14 Port2 7.82e-12
L15 N14 Port2 4.02e-11
R15 N14 Port2 1.76e+01
.ENDS GRM21BR70J106KE76
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM21BR70J106MA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR70J106MA73 Port1 Port2
C01 Port1 N01 6.49e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.55e-10
R03 N02 N03 3.00e-03
C04 N03 N04 1.15e-04
R04 N03 N04 4.60e+01
C05 N04 N05 1.94e-04
R05 N04 N05 1.69e+00
C06 N05 N06 1.75e-04
R06 N05 N06 1.30e-01
C07 N06 N07 1.36e-04
R07 N06 N07 1.21e-02
C08 N07 N08 5.68e-04
R08 N07 N08 2.29e-04
L09 N08 N09 4.13e-11
R09 N08 N09 3.53e-02
L10 N09 N10 3.30e-10
R10 N09 N10 1.75e-02
C11 N10 N11 2.90e-05
L11 N10 N11 4.14e-11
R11 N10 N11 4.76e-03
C12 N11 N12 1.56e-05
L12 N11 N12 3.95e-11
R12 N11 N12 4.16e-03
C13 N12 Port2 6.42e-12
L13 N12 Port2 1.04e-10
R13 N12 Port2 1.01e+01
.ENDS GRM21BR70J106MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRM21BR70J106ME76
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR70J106ME76 Port1 Port2
C01 Port1 N01 7.03e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.42e-10
R03 N02 N03 3.02e-03
C04 N03 N04 1.75e-04
R04 N03 N04 3.03e+01
C05 N04 N05 1.96e-04
R05 N04 N05 2.25e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.25e-01
C07 N06 N07 1.56e-04
R07 N06 N07 2.57e-02
C08 N07 N08 1.37e-04
R08 N07 N08 3.09e-03
L09 N08 N09 1.55e-11
R09 N08 N09 1.05e-01
L10 N09 N10 3.92e-11
R10 N09 N10 3.14e-02
L11 N10 N11 3.62e-10
R11 N10 N11 1.71e-02
C12 N11 N12 1.61e-05
L12 N11 N12 7.22e-11
R12 N11 N12 4.78e-03
C13 N12 N13 3.70e-05
L13 N12 N13 1.71e-11
R13 N12 N13 2.88e-03
C14 N13 N14 7.98e-12
L14 N13 N14 8.68e-11
R14 N13 N14 1.07e+01
C15 N14 Port2 7.82e-12
L15 N14 Port2 4.02e-11
R15 N14 Port2 1.76e+01
.ENDS GRM21BR70J106ME76
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRM21BR70J225KA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR70J225KA01 Port1 Port2
C01 Port1 N01 2.18e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 9.47e-11
R03 N02 N03 3.18e-03
C04 N03 N04 8.47e-05
R04 N03 N04 7.89e+01
C05 N04 N05 2.42e-04
R05 N04 N05 1.65e+00
C06 N05 N06 2.11e-04
R06 N05 N06 1.89e-01
C07 N06 N07 2.02e-04
R07 N06 N07 2.01e-02
C08 N07 N08 1.83e-04
R08 N07 N08 3.15e-03
L09 N08 N09 2.47e-11
R09 N08 N09 2.97e-02
L10 N09 N10 2.39e-10
R10 N09 N10 2.71e-02
C11 N10 N11 6.04e-06
L11 N10 N11 6.28e-11
R11 N10 N11 1.18e-02
C12 N11 N12 4.07e-06
L12 N11 N12 4.37e-11
R12 N11 N12 1.03e-02
C13 N12 N13 8.01e-12
L13 N12 N13 8.49e-11
R13 N12 N13 1.04e+01
C14 N13 Port2 2.97e-12
L14 N13 Port2 1.02e-10
R14 N13 Port2 2.55e+01
.ENDS GRM21BR70J225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRM21BR71A105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71A105KA01 Port1 Port2
C01 Port1 N01 9.33e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.89e-10
R03 N02 N03 4.90e-03
C04 N03 N04 1.81e-04
R04 N03 N04 6.47e+00
C05 N04 N05 1.23e-04
R05 N04 N05 7.97e-01
C06 N05 N06 1.13e-04
R06 N05 N06 9.92e-02
C07 N06 N07 7.87e-05
R07 N06 N07 1.33e-02
L08 N07 N08 1.81e-11
R08 N07 N08 5.44e-02
L09 N08 N09 1.88e-10
R09 N08 N09 3.80e-02
C10 N09 N10 3.05e-06
L10 N09 N10 5.20e-11
R10 N09 N10 1.67e-02
C11 N10 N11 1.74e-06
L11 N10 N11 4.23e-11
R11 N10 N11 1.75e-02
C12 N11 N12 8.19e-12
L12 N11 N12 9.37e-11
R12 N11 N12 1.03e+01
C13 N12 Port2 5.87e-12
L13 N12 Port2 5.67e-11
R13 N12 Port2 1.96e+01
.ENDS GRM21BR71A105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM21BR71A106KA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71A106KA73 Port1 Port2
C01 Port1 N01 6.45e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.68e-10
R03 N02 N03 3.05e-03
C04 N03 N04 2.17e-04
R04 N03 N04 1.45e+01
C05 N04 N05 2.26e-04
R05 N04 N05 1.41e+00
C06 N05 N06 2.20e-04
R06 N05 N06 1.50e-01
C07 N06 N07 1.82e-04
R07 N06 N07 1.91e-02
C08 N07 N08 2.02e-04
R08 N07 N08 2.52e-03
L09 N08 N09 2.14e-11
R09 N08 N09 5.14e-02
L10 N09 N10 5.44e-11
R10 N09 N10 1.50e-02
L11 N10 N11 2.62e-10
R11 N10 N11 1.39e-02
C12 N11 N12 2.49e-05
L12 N11 N12 4.93e-11
R12 N11 N12 5.09e-03
C13 N12 N13 1.05e-05
L13 N12 N13 5.73e-11
R13 N12 N13 5.56e-03
C14 N13 N14 1.49e-11
L14 N13 N14 4.83e-11
R14 N13 N14 7.86e+00
C15 N14 Port2 5.84e-12
L15 N14 Port2 5.35e-11
R15 N14 Port2 1.05e+01
.ENDS GRM21BR71A106KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM21BR71A106KE51
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71A106KE51 Port1 Port2
C01 Port1 N01 7.03e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.42e-10
R03 N02 N03 3.02e-03
C04 N03 N04 1.75e-04
R04 N03 N04 3.03e+01
C05 N04 N05 1.96e-04
R05 N04 N05 2.25e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.25e-01
C07 N06 N07 1.56e-04
R07 N06 N07 2.57e-02
C08 N07 N08 1.37e-04
R08 N07 N08 3.09e-03
L09 N08 N09 1.55e-11
R09 N08 N09 1.05e-01
L10 N09 N10 3.92e-11
R10 N09 N10 3.14e-02
L11 N10 N11 3.62e-10
R11 N10 N11 1.71e-02
C12 N11 N12 1.61e-05
L12 N11 N12 7.22e-11
R12 N11 N12 4.78e-03
C13 N12 N13 3.70e-05
L13 N12 N13 1.71e-11
R13 N12 N13 2.88e-03
C14 N13 N14 7.98e-12
L14 N13 N14 8.68e-11
R14 N13 N14 1.07e+01
C15 N14 Port2 7.82e-12
L15 N14 Port2 4.02e-11
R15 N14 Port2 1.76e+01
.ENDS GRM21BR71A106KE51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM21BR71A106MA73
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71A106MA73 Port1 Port2
C01 Port1 N01 6.45e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.68e-10
R03 N02 N03 3.05e-03
C04 N03 N04 2.17e-04
R04 N03 N04 1.45e+01
C05 N04 N05 2.26e-04
R05 N04 N05 1.41e+00
C06 N05 N06 2.20e-04
R06 N05 N06 1.50e-01
C07 N06 N07 1.82e-04
R07 N06 N07 1.91e-02
C08 N07 N08 2.02e-04
R08 N07 N08 2.52e-03
L09 N08 N09 2.14e-11
R09 N08 N09 5.14e-02
L10 N09 N10 5.44e-11
R10 N09 N10 1.50e-02
L11 N10 N11 2.62e-10
R11 N10 N11 1.39e-02
C12 N11 N12 2.49e-05
L12 N11 N12 4.93e-11
R12 N11 N12 5.09e-03
C13 N12 N13 1.05e-05
L13 N12 N13 5.73e-11
R13 N12 N13 5.56e-03
C14 N13 N14 1.49e-11
L14 N13 N14 4.83e-11
R14 N13 N14 7.86e+00
C15 N14 Port2 5.84e-12
L15 N14 Port2 5.35e-11
R15 N14 Port2 1.05e+01
.ENDS GRM21BR71A106MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRM21BR71A106ME51
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71A106ME51 Port1 Port2
C01 Port1 N01 7.03e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.42e-10
R03 N02 N03 3.02e-03
C04 N03 N04 1.75e-04
R04 N03 N04 3.03e+01
C05 N04 N05 1.96e-04
R05 N04 N05 2.25e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.25e-01
C07 N06 N07 1.56e-04
R07 N06 N07 2.57e-02
C08 N07 N08 1.37e-04
R08 N07 N08 3.09e-03
L09 N08 N09 1.55e-11
R09 N08 N09 1.05e-01
L10 N09 N10 3.92e-11
R10 N09 N10 3.14e-02
L11 N10 N11 3.62e-10
R11 N10 N11 1.71e-02
C12 N11 N12 1.61e-05
L12 N11 N12 7.22e-11
R12 N11 N12 4.78e-03
C13 N12 N13 3.70e-05
L13 N12 N13 1.71e-11
R13 N12 N13 2.88e-03
C14 N13 N14 7.98e-12
L14 N13 N14 8.68e-11
R14 N13 N14 1.07e+01
C15 N14 Port2 7.82e-12
L15 N14 Port2 4.02e-11
R15 N14 Port2 1.76e+01
.ENDS GRM21BR71A106ME51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRM21BR71A225KA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71A225KA01 Port1 Port2
C01 Port1 N01 2.18e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 9.47e-11
R03 N02 N03 3.18e-03
C04 N03 N04 8.47e-05
R04 N03 N04 7.89e+01
C05 N04 N05 2.42e-04
R05 N04 N05 1.65e+00
C06 N05 N06 2.11e-04
R06 N05 N06 1.89e-01
C07 N06 N07 2.02e-04
R07 N06 N07 2.01e-02
C08 N07 N08 1.83e-04
R08 N07 N08 3.15e-03
L09 N08 N09 2.47e-11
R09 N08 N09 2.97e-02
L10 N09 N10 2.39e-10
R10 N09 N10 2.71e-02
C11 N10 N11 6.04e-06
L11 N10 N11 6.28e-11
R11 N10 N11 1.18e-02
C12 N11 N12 4.07e-06
L12 N11 N12 4.37e-11
R12 N11 N12 1.03e-02
C13 N12 N13 8.01e-12
L13 N12 N13 8.49e-11
R13 N12 N13 1.04e+01
C14 N13 Port2 2.97e-12
L14 N13 Port2 1.02e-10
R14 N13 Port2 2.55e+01
.ENDS GRM21BR71A225KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/10[V]
* Murata P/N :GRM21BR71A225MA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71A225MA01 Port1 Port2
C01 Port1 N01 2.18e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 9.47e-11
R03 N02 N03 3.18e-03
C04 N03 N04 8.47e-05
R04 N03 N04 7.89e+01
C05 N04 N05 2.42e-04
R05 N04 N05 1.65e+00
C06 N05 N06 2.11e-04
R06 N05 N06 1.89e-01
C07 N06 N07 2.02e-04
R07 N06 N07 2.01e-02
C08 N07 N08 1.83e-04
R08 N07 N08 3.15e-03
L09 N08 N09 2.47e-11
R09 N08 N09 2.97e-02
L10 N09 N10 2.39e-10
R10 N09 N10 2.71e-02
C11 N10 N11 6.04e-06
L11 N10 N11 6.28e-11
R11 N10 N11 1.18e-02
C12 N11 N12 4.07e-06
L12 N11 N12 4.37e-11
R12 N11 N12 1.03e-02
C13 N12 N13 8.01e-12
L13 N12 N13 8.49e-11
R13 N12 N13 1.04e+01
C14 N13 Port2 2.97e-12
L14 N13 Port2 1.02e-10
R14 N13 Port2 2.55e+01
.ENDS GRM21BR71A225MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM21BR71A475KA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71A475KA73 Port1 Port2
C01 Port1 N01 2.83e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.18e-10
R03 N02 N03 4.38e-03
C04 N03 N04 5.43e-05
R04 N03 N04 9.77e+01
C05 N04 N05 8.82e-05
R05 N04 N05 4.59e+00
C06 N05 N06 8.14e-05
R06 N05 N06 5.03e-01
C07 N06 N07 6.62e-05
R07 N06 N07 6.10e-02
C08 N07 N08 5.31e-05
R08 N07 N08 7.46e-03
L09 N08 N09 3.09e-11
R09 N08 N09 3.60e-02
L10 N09 N10 2.30e-10
R10 N09 N10 2.28e-02
C11 N10 N11 9.80e-06
L11 N10 N11 4.27e-11
R11 N10 N11 6.69e-03
C12 N11 N12 3.73e-06
L12 N11 N12 5.27e-11
R12 N11 N12 8.26e-03
C13 N12 N13 8.49e-12
L13 N12 N13 1.12e-10
R13 N12 N13 1.40e+01
C14 N13 Port2 3.17e-12
L14 N13 Port2 1.07e-10
R14 N13 Port2 2.99e+01
.ENDS GRM21BR71A475KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM21BR71A475KE51
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71A475KE51 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.04e-10
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 1.50e-11
L14 N13 N14 5.47e-11
R14 N13 N14 9.30e+00
C15 N14 Port2 1.96e-12
L15 N14 Port2 1.18e-10
R15 N14 Port2 2.13e+01
.ENDS GRM21BR71A475KE51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM21BR71A475MA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71A475MA73 Port1 Port2
C01 Port1 N01 2.83e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.18e-10
R03 N02 N03 4.38e-03
C04 N03 N04 5.43e-05
R04 N03 N04 9.77e+01
C05 N04 N05 8.82e-05
R05 N04 N05 4.59e+00
C06 N05 N06 8.14e-05
R06 N05 N06 5.03e-01
C07 N06 N07 6.62e-05
R07 N06 N07 6.10e-02
C08 N07 N08 5.31e-05
R08 N07 N08 7.46e-03
L09 N08 N09 3.09e-11
R09 N08 N09 3.60e-02
L10 N09 N10 2.30e-10
R10 N09 N10 2.28e-02
C11 N10 N11 9.80e-06
L11 N10 N11 4.27e-11
R11 N10 N11 6.69e-03
C12 N11 N12 3.73e-06
L12 N11 N12 5.27e-11
R12 N11 N12 8.26e-03
C13 N12 N13 8.49e-12
L13 N12 N13 1.12e-10
R13 N12 N13 1.40e+01
C14 N13 Port2 3.17e-12
L14 N13 Port2 1.07e-10
R14 N13 Port2 2.99e+01
.ENDS GRM21BR71A475MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/10[V]
* Murata P/N :GRM21BR71A475ME51
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71A475ME51 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.04e-10
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 1.50e-11
L14 N13 N14 5.47e-11
R14 N13 N14 9.30e+00
C15 N14 Port2 1.96e-12
L15 N14 Port2 1.18e-10
R15 N14 Port2 2.13e+01
.ENDS GRM21BR71A475ME51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GRM21BR71C105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71C105KA01 Port1 Port2
C01 Port1 N01 9.33e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.89e-10
R03 N02 N03 4.90e-03
C04 N03 N04 1.81e-04
R04 N03 N04 6.47e+00
C05 N04 N05 1.23e-04
R05 N04 N05 7.97e-01
C06 N05 N06 1.13e-04
R06 N05 N06 9.92e-02
C07 N06 N07 7.87e-05
R07 N06 N07 1.33e-02
L08 N07 N08 1.81e-11
R08 N07 N08 5.44e-02
L09 N08 N09 1.88e-10
R09 N08 N09 3.80e-02
C10 N09 N10 3.05e-06
L10 N09 N10 5.20e-11
R10 N09 N10 1.67e-02
C11 N10 N11 1.74e-06
L11 N10 N11 4.23e-11
R11 N10 N11 1.75e-02
C12 N11 N12 8.19e-12
L12 N11 N12 9.37e-11
R12 N11 N12 1.03e+01
C13 N12 Port2 5.87e-12
L13 N12 Port2 5.67e-11
R13 N12 Port2 1.96e+01
.ENDS GRM21BR71C105KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GRM21BR71C224KA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71C224KA01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 8.13e-11
R03 N02 N03 1.05e-02
C04 N03 N04 3.32e-05
R04 N03 N04 1.20e+02
C05 N04 N05 7.33e-05
R05 N04 N05 1.14e+01
C06 N05 N06 4.01e-05
R06 N05 N06 5.11e+00
C07 N06 N07 4.58e-05
R07 N06 N07 7.56e-01
C08 N07 N08 3.44e-05
R08 N07 N08 1.81e-01
C09 N08 N09 3.92e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.87e-05
R10 N09 N10 1.34e-02
C11 N10 N11 1.98e-05
R11 N10 N11 1.69e-03
C12 N11 N12 5.30e+00
R12 N11 N12 3.00e-06
L13 N12 N13 1.37e-10
R13 N12 N13 5.78e-02
C14 N13 N14 1.22e-06
L14 N13 N14 2.66e-11
R14 N13 N14 1.76e-02
C15 N14 N15 3.20e-07
L15 N14 N15 4.28e-11
R15 N14 N15 2.44e-02
C16 N15 N16 8.80e-12
L16 N15 N16 1.19e-10
R16 N15 N16 9.16e+00
C17 N16 Port2 1.40e-12
L17 N16 Port2 2.16e-10
R17 N16 Port2 2.71e+01
.ENDS GRM21BR71C224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GRM21BR71C224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71C224MA01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 8.13e-11
R03 N02 N03 1.05e-02
C04 N03 N04 3.32e-05
R04 N03 N04 1.20e+02
C05 N04 N05 7.33e-05
R05 N04 N05 1.14e+01
C06 N05 N06 4.01e-05
R06 N05 N06 5.11e+00
C07 N06 N07 4.58e-05
R07 N06 N07 7.56e-01
C08 N07 N08 3.44e-05
R08 N07 N08 1.81e-01
C09 N08 N09 3.92e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.87e-05
R10 N09 N10 1.34e-02
C11 N10 N11 1.98e-05
R11 N10 N11 1.69e-03
C12 N11 N12 5.30e+00
R12 N11 N12 3.00e-06
L13 N12 N13 1.37e-10
R13 N12 N13 5.78e-02
C14 N13 N14 1.22e-06
L14 N13 N14 2.66e-11
R14 N13 N14 1.76e-02
C15 N14 N15 3.20e-07
L15 N14 N15 4.28e-11
R15 N14 N15 2.44e-02
C16 N15 N16 8.80e-12
L16 N15 N16 1.19e-10
R16 N15 N16 9.16e+00
C17 N16 Port2 1.40e-12
L17 N16 Port2 2.16e-10
R17 N16 Port2 2.71e+01
.ENDS GRM21BR71C224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRM21BR71C225KA12
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71C225KA12 Port1 Port2
C01 Port1 N01 2.18e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 9.47e-11
R03 N02 N03 3.18e-03
C04 N03 N04 8.47e-05
R04 N03 N04 7.89e+01
C05 N04 N05 2.42e-04
R05 N04 N05 1.65e+00
C06 N05 N06 2.11e-04
R06 N05 N06 1.89e-01
C07 N06 N07 2.02e-04
R07 N06 N07 2.01e-02
C08 N07 N08 1.83e-04
R08 N07 N08 3.15e-03
L09 N08 N09 2.47e-11
R09 N08 N09 2.97e-02
L10 N09 N10 2.39e-10
R10 N09 N10 2.71e-02
C11 N10 N11 6.04e-06
L11 N10 N11 6.28e-11
R11 N10 N11 1.18e-02
C12 N11 N12 4.07e-06
L12 N11 N12 4.37e-11
R12 N11 N12 1.03e-02
C13 N12 N13 8.01e-12
L13 N12 N13 8.49e-11
R13 N12 N13 1.04e+01
C14 N13 Port2 2.97e-12
L14 N13 Port2 1.02e-10
R14 N13 Port2 2.55e+01
.ENDS GRM21BR71C225KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GRM21BR71C225MA12
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71C225MA12 Port1 Port2
C01 Port1 N01 2.18e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 9.47e-11
R03 N02 N03 3.18e-03
C04 N03 N04 8.47e-05
R04 N03 N04 7.89e+01
C05 N04 N05 2.42e-04
R05 N04 N05 1.65e+00
C06 N05 N06 2.11e-04
R06 N05 N06 1.89e-01
C07 N06 N07 2.02e-04
R07 N06 N07 2.01e-02
C08 N07 N08 1.83e-04
R08 N07 N08 3.15e-03
L09 N08 N09 2.47e-11
R09 N08 N09 2.97e-02
L10 N09 N10 2.39e-10
R10 N09 N10 2.71e-02
C11 N10 N11 6.04e-06
L11 N10 N11 6.28e-11
R11 N10 N11 1.18e-02
C12 N11 N12 4.07e-06
L12 N11 N12 4.37e-11
R12 N11 N12 1.03e-02
C13 N12 N13 8.01e-12
L13 N12 N13 8.49e-11
R13 N12 N13 1.04e+01
C14 N13 Port2 2.97e-12
L14 N13 Port2 1.02e-10
R14 N13 Port2 2.55e+01
.ENDS GRM21BR71C225MA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GRM21BR71C474MA01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71C474MA01 Port1 Port2
C01 Port1 N01 4.65e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.56e-10
R03 N02 N03 5.56e-03
C04 N03 N04 5.02e-05
R04 N03 N04 7.93e+01
C05 N04 N05 7.94e-05
R05 N04 N05 9.10e+00
C06 N05 N06 6.13e-05
R06 N05 N06 1.99e+00
C07 N06 N07 5.04e-05
R07 N06 N07 3.16e-01
C08 N07 N08 4.63e-05
R08 N07 N08 3.45e-02
C09 N08 N09 4.89e-05
R09 N08 N09 4.41e-03
L10 N09 N10 2.27e-10
R10 N09 N10 5.40e-02
L11 N10 N11 1.03e-11
R11 N10 N11 3.66e-02
C12 N11 N12 2.10e-06
L12 N11 N12 3.94e-11
R12 N11 N12 2.19e-02
C13 N12 N13 9.07e-07
L13 N12 N13 4.56e-11
R13 N12 N13 2.65e-02
C14 N13 N14 1.30e-11
L14 N13 N14 8.23e-11
R14 N13 N14 7.19e+00
C15 N14 Port2 3.20e-12
L15 N14 Port2 1.02e-10
R15 N14 Port2 1.05e+01
.ENDS GRM21BR71C474MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM21BR71C475KA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71C475KA73 Port1 Port2
C01 Port1 N01 2.83e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.18e-10
R03 N02 N03 4.38e-03
C04 N03 N04 5.43e-05
R04 N03 N04 9.77e+01
C05 N04 N05 8.82e-05
R05 N04 N05 4.59e+00
C06 N05 N06 8.14e-05
R06 N05 N06 5.03e-01
C07 N06 N07 6.62e-05
R07 N06 N07 6.10e-02
C08 N07 N08 5.31e-05
R08 N07 N08 7.46e-03
L09 N08 N09 3.09e-11
R09 N08 N09 3.60e-02
L10 N09 N10 2.30e-10
R10 N09 N10 2.28e-02
C11 N10 N11 9.80e-06
L11 N10 N11 4.27e-11
R11 N10 N11 6.69e-03
C12 N11 N12 3.73e-06
L12 N11 N12 5.27e-11
R12 N11 N12 8.26e-03
C13 N12 N13 8.49e-12
L13 N12 N13 1.12e-10
R13 N12 N13 1.40e+01
C14 N13 Port2 3.17e-12
L14 N13 Port2 1.07e-10
R14 N13 Port2 2.99e+01
.ENDS GRM21BR71C475KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM21BR71C475KE51
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71C475KE51 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.04e-10
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 1.50e-11
L14 N13 N14 5.47e-11
R14 N13 N14 9.30e+00
C15 N14 Port2 1.96e-12
L15 N14 Port2 1.18e-10
R15 N14 Port2 2.13e+01
.ENDS GRM21BR71C475KE51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM21BR71C475MA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71C475MA73 Port1 Port2
C01 Port1 N01 2.83e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.18e-10
R03 N02 N03 4.38e-03
C04 N03 N04 5.43e-05
R04 N03 N04 9.77e+01
C05 N04 N05 8.82e-05
R05 N04 N05 4.59e+00
C06 N05 N06 8.14e-05
R06 N05 N06 5.03e-01
C07 N06 N07 6.62e-05
R07 N06 N07 6.10e-02
C08 N07 N08 5.31e-05
R08 N07 N08 7.46e-03
L09 N08 N09 3.09e-11
R09 N08 N09 3.60e-02
L10 N09 N10 2.30e-10
R10 N09 N10 2.28e-02
C11 N10 N11 9.80e-06
L11 N10 N11 4.27e-11
R11 N10 N11 6.69e-03
C12 N11 N12 3.73e-06
L12 N11 N12 5.27e-11
R12 N11 N12 8.26e-03
C13 N12 N13 8.49e-12
L13 N12 N13 1.12e-10
R13 N12 N13 1.40e+01
C14 N13 Port2 3.17e-12
L14 N13 Port2 1.07e-10
R14 N13 Port2 2.99e+01
.ENDS GRM21BR71C475MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRM21BR71C475ME51
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71C475ME51 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.04e-10
R03 N02 N03 3.69e-03
C04 N03 N04 5.83e-05
R04 N03 N04 9.53e+01
C05 N04 N05 1.34e-04
R05 N04 N05 4.21e+00
C06 N05 N06 1.10e-04
R06 N05 N06 4.75e-01
C07 N06 N07 9.23e-05
R07 N06 N07 5.65e-02
C08 N07 N08 7.70e-05
R08 N07 N08 6.73e-03
L09 N08 N09 7.86e-12
R09 N08 N09 4.04e-02
L10 N09 N10 2.45e-11
R10 N09 N10 2.55e-02
L11 N10 N11 2.68e-10
R11 N10 N11 2.22e-02
C12 N11 N12 1.02e-05
L12 N11 N12 5.22e-11
R12 N11 N12 5.91e-03
C13 N12 N13 6.29e-06
L13 N12 N13 4.32e-11
R13 N12 N13 6.03e-03
C14 N13 N14 1.50e-11
L14 N13 N14 5.47e-11
R14 N13 N14 9.30e+00
C15 N14 Port2 1.96e-12
L15 N14 Port2 1.18e-10
R15 N14 Port2 2.13e+01
.ENDS GRM21BR71C475ME51
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GRM21BR71E104JA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E104JA01 Port1 Port2
C01 Port1 N01 9.92e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.57e-10
R03 N02 N03 1.38e-02
C04 N03 N04 1.24e-05
R04 N03 N04 3.20e+02
C05 N04 N05 1.85e-05
R05 N04 N05 3.12e+01
C06 N05 N06 1.52e-05
R06 N05 N06 5.55e+00
C07 N06 N07 1.25e-05
R07 N06 N07 8.22e-01
C08 N07 N08 8.71e-06
R08 N07 N08 1.03e-01
C09 N08 N09 8.59e-06
R09 N08 N09 1.38e-02
L10 N09 N10 2.07e-11
R10 N09 N10 1.52e-01
L11 N10 N11 1.38e-10
R11 N10 N11 1.10e-01
C12 N11 N12 3.41e-07
L12 N11 N12 4.14e-11
R12 N11 N12 4.84e-02
C13 N12 N13 1.50e-07
L13 N12 N13 4.24e-11
R13 N12 N13 5.34e-02
C14 N13 N14 1.01e-11
L14 N13 N14 1.01e-10
R14 N13 N14 1.06e+01
C15 N14 Port2 3.04e-12
L15 N14 Port2 1.15e-10
R15 N14 Port2 2.08e+01
.ENDS GRM21BR71E104JA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GRM21BR71E104KA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E104KA01 Port1 Port2
C01 Port1 N01 9.64e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.44e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.45e-05
R04 N03 N04 1.10e+00
C05 N04 N05 8.53e-06
R05 N04 N05 4.23e-01
C06 N05 N06 1.00e-05
R06 N05 N06 6.88e-02
C07 N06 N07 1.56e-05
R07 N06 N07 1.59e-02
C08 N07 N08 9.93e-06
R08 N07 N08 5.77e-03
L09 N08 N09 1.43e-10
R09 N08 N09 8.30e-02
L10 N09 N10 5.40e-13
R10 N09 N10 5.13e-03
C11 N10 N11 5.81e-07
L11 N10 N11 2.53e-11
R11 N10 N11 3.22e-02
C12 N11 N12 1.40e-07
L12 N11 N12 5.04e-11
R12 N11 N12 4.66e-02
C13 N12 N13 1.08e-11
L13 N12 N13 1.01e-10
R13 N12 N13 9.45e+00
C14 N13 Port2 2.59e-12
L14 N13 Port2 1.34e-10
R14 N13 Port2 1.59e+01
.ENDS GRM21BR71E104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :GRM21BR71E104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E104MA01 Port1 Port2
C01 Port1 N01 9.64e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.44e-10
R03 N02 N03 1.43e-02
C04 N03 N04 1.45e-05
R04 N03 N04 1.10e+00
C05 N04 N05 8.53e-06
R05 N04 N05 4.23e-01
C06 N05 N06 1.00e-05
R06 N05 N06 6.88e-02
C07 N06 N07 1.56e-05
R07 N06 N07 1.59e-02
C08 N07 N08 9.93e-06
R08 N07 N08 5.77e-03
L09 N08 N09 1.43e-10
R09 N08 N09 8.30e-02
L10 N09 N10 5.40e-13
R10 N09 N10 5.13e-03
C11 N10 N11 5.81e-07
L11 N10 N11 2.53e-11
R11 N10 N11 3.22e-02
C12 N11 N12 1.40e-07
L12 N11 N12 5.04e-11
R12 N11 N12 4.66e-02
C13 N12 N13 1.08e-11
L13 N12 N13 1.01e-10
R13 N12 N13 9.45e+00
C14 N13 Port2 2.59e-12
L14 N13 Port2 1.34e-10
R14 N13 Port2 1.59e+01
.ENDS GRM21BR71E104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRM21BR71E105KA99
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E105KA99 Port1 Port2
C01 Port1 N01 1.02e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 1.06e-10
R03 N02 N03 4.89e-03
C04 N03 N04 2.36e-05
R04 N03 N04 3.04e+02
C05 N04 N05 1.12e-04
R05 N04 N05 3.04e+00
C06 N05 N06 1.14e-04
R06 N05 N06 3.00e-01
C07 N06 N07 9.26e-05
R07 N06 N07 3.66e-02
C08 N07 N08 6.76e-05
R08 N07 N08 5.29e-03
L09 N08 N09 1.84e-11
R09 N08 N09 5.34e-02
L10 N09 N10 1.99e-10
R10 N09 N10 3.69e-02
C11 N10 N11 2.43e-06
L11 N10 N11 7.08e-11
R11 N10 N11 1.57e-02
C12 N11 N12 1.83e-06
L12 N11 N12 4.21e-11
R12 N11 N12 1.57e-02
C13 N12 N13 1.51e-11
L13 N12 N13 7.39e-11
R13 N12 N13 8.53e+00
C14 N13 Port2 2.10e-12
L14 N13 Port2 1.47e-10
R14 N13 Port2 2.33e+01
.ENDS GRM21BR71E105KA99
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GRM21BR71E154KA01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E154KA01 Port1 Port2
C01 Port1 N01 1.49e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 2.16e-10
R03 N02 N03 1.36e-02
C04 N03 N04 1.98e-05
R04 N03 N04 2.01e+02
C05 N04 N05 3.78e-05
R05 N04 N05 1.91e+01
C06 N05 N06 2.60e-05
R06 N05 N06 4.70e+00
C07 N06 N07 2.69e-05
R07 N06 N07 7.11e-01
C08 N07 N08 2.02e-05
R08 N07 N08 1.22e-01
C09 N08 N09 9.76e-06
R09 N08 N09 2.24e-02
L10 N09 N10 1.41e-10
R10 N09 N10 6.41e-02
L11 N10 N11 8.96e-12
R11 N10 N11 2.99e-02
C12 N11 N12 9.52e-07
L12 N11 N12 2.55e-11
R12 N11 N12 1.77e-02
C13 N12 N13 2.56e-07
L13 N12 N13 3.19e-11
R13 N12 N13 2.07e-02
C14 N13 N14 7.73e-12
L14 N13 N14 1.42e-10
R14 N13 N14 1.07e+01
C15 N14 Port2 4.83e-12
L15 N14 Port2 6.46e-11
R15 N14 Port2 2.55e+01
.ENDS GRM21BR71E154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRM21BR71E224KA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E224KA01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 8.13e-11
R03 N02 N03 1.05e-02
C04 N03 N04 3.32e-05
R04 N03 N04 1.20e+02
C05 N04 N05 7.33e-05
R05 N04 N05 1.14e+01
C06 N05 N06 4.01e-05
R06 N05 N06 5.11e+00
C07 N06 N07 4.58e-05
R07 N06 N07 7.56e-01
C08 N07 N08 3.44e-05
R08 N07 N08 1.81e-01
C09 N08 N09 3.92e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.87e-05
R10 N09 N10 1.34e-02
C11 N10 N11 1.98e-05
R11 N10 N11 1.69e-03
C12 N11 N12 5.30e+00
R12 N11 N12 3.00e-06
L13 N12 N13 1.37e-10
R13 N12 N13 5.78e-02
C14 N13 N14 1.22e-06
L14 N13 N14 2.66e-11
R14 N13 N14 1.76e-02
C15 N14 N15 3.20e-07
L15 N14 N15 4.28e-11
R15 N14 N15 2.44e-02
C16 N15 N16 8.80e-12
L16 N15 N16 1.19e-10
R16 N15 N16 9.16e+00
C17 N16 Port2 1.40e-12
L17 N16 Port2 2.16e-10
R17 N16 Port2 2.71e+01
.ENDS GRM21BR71E224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRM21BR71E224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E224MA01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 8.13e-11
R03 N02 N03 1.05e-02
C04 N03 N04 3.32e-05
R04 N03 N04 1.20e+02
C05 N04 N05 7.33e-05
R05 N04 N05 1.14e+01
C06 N05 N06 4.01e-05
R06 N05 N06 5.11e+00
C07 N06 N07 4.58e-05
R07 N06 N07 7.56e-01
C08 N07 N08 3.44e-05
R08 N07 N08 1.81e-01
C09 N08 N09 3.92e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.87e-05
R10 N09 N10 1.34e-02
C11 N10 N11 1.98e-05
R11 N10 N11 1.69e-03
C12 N11 N12 5.30e+00
R12 N11 N12 3.00e-06
L13 N12 N13 1.37e-10
R13 N12 N13 5.78e-02
C14 N13 N14 1.22e-06
L14 N13 N14 2.66e-11
R14 N13 N14 1.76e-02
C15 N14 N15 3.20e-07
L15 N14 N15 4.28e-11
R15 N14 N15 2.44e-02
C16 N15 N16 8.80e-12
L16 N15 N16 1.19e-10
R16 N15 N16 9.16e+00
C17 N16 Port2 1.40e-12
L17 N16 Port2 2.16e-10
R17 N16 Port2 2.71e+01
.ENDS GRM21BR71E224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM21BR71E225KA73
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E225KA73 Port1 Port2
C01 Port1 N01 1.85e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.41e-10
R03 N02 N03 4.83e-03
C04 N03 N04 1.77e-05
R04 N03 N04 3.86e+02
C05 N04 N05 5.67e-05
R05 N04 N05 8.49e+00
C06 N05 N06 4.92e-05
R06 N05 N06 9.87e-01
C07 N06 N07 3.91e-05
R07 N06 N07 1.23e-01
C08 N07 N08 2.92e-05
R08 N07 N08 1.64e-02
L09 N08 N09 7.30e-12
R09 N08 N09 4.41e-02
L10 N09 N10 2.22e-11
R10 N09 N10 3.12e-02
L11 N10 N11 2.40e-10
R11 N10 N11 3.08e-02
C12 N11 N12 5.46e-06
L12 N11 N12 4.73e-11
R12 N11 N12 1.20e-02
C13 N12 N13 2.78e-06
L13 N12 N13 4.65e-11
R13 N12 N13 1.18e-02
C14 N13 N14 1.08e-11
L14 N13 N14 6.86e-11
R14 N13 N14 8.28e+00
C15 N14 Port2 5.99e-12
L15 N14 Port2 4.94e-11
R15 N14 Port2 7.29e+00
.ENDS GRM21BR71E225KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM21BR71E225KE11
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E225KE11 Port1 Port2
C01 Port1 N01 1.54e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 6.96e-11
R03 N02 N03 5.31e-03
C04 N03 N04 5.73e-05
R04 N03 N04 1.89e+01
C05 N04 N05 6.18e-05
R05 N04 N05 1.89e+00
C06 N05 N06 5.69e-05
R06 N05 N06 2.43e-01
C07 N06 N07 4.83e-05
R07 N06 N07 4.09e-02
C08 N07 N08 3.71e-05
R08 N07 N08 8.90e-03
L09 N08 N09 2.15e-11
R09 N08 N09 8.28e-02
L10 N09 N10 1.76e-10
R10 N09 N10 3.78e-02
C11 N10 N11 4.17e-06
L11 N10 N11 5.62e-11
R11 N10 N11 1.39e-02
C12 N11 N12 1.59e-06
L12 N11 N12 6.69e-11
R12 N11 N12 1.58e-02
C13 N12 N13 1.49e-11
L13 N12 N13 5.47e-11
R13 N12 N13 9.57e+00
C14 N13 Port2 1.66e-12
L14 N13 Port2 1.38e-10
R14 N13 Port2 2.51e+01
.ENDS GRM21BR71E225KE11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRM21BR71E225ME11
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E225ME11 Port1 Port2
C01 Port1 N01 1.54e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 6.96e-11
R03 N02 N03 5.31e-03
C04 N03 N04 5.73e-05
R04 N03 N04 1.89e+01
C05 N04 N05 6.18e-05
R05 N04 N05 1.89e+00
C06 N05 N06 5.69e-05
R06 N05 N06 2.43e-01
C07 N06 N07 4.83e-05
R07 N06 N07 4.09e-02
C08 N07 N08 3.71e-05
R08 N07 N08 8.90e-03
L09 N08 N09 2.15e-11
R09 N08 N09 8.28e-02
L10 N09 N10 1.76e-10
R10 N09 N10 3.78e-02
C11 N10 N11 4.17e-06
L11 N10 N11 5.62e-11
R11 N10 N11 1.39e-02
C12 N11 N12 1.59e-06
L12 N11 N12 6.69e-11
R12 N11 N12 1.58e-02
C13 N12 N13 1.49e-11
L13 N12 N13 5.47e-11
R13 N12 N13 9.57e+00
C14 N13 Port2 1.66e-12
L14 N13 Port2 1.38e-10
R14 N13 Port2 2.51e+01
.ENDS GRM21BR71E225ME11
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/25[V]
* Murata P/N :GRM21BR71E334KA01
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E334KA01 Port1 Port2
C01 Port1 N01 3.19e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.07e-10
R03 N02 N03 6.23e-03
C04 N03 N04 4.27e-05
R04 N03 N04 9.32e+01
C05 N04 N05 7.24e-05
R05 N04 N05 9.99e+00
C06 N05 N06 5.76e-05
R06 N05 N06 2.14e+00
C07 N06 N07 8.51e-05
R07 N06 N07 2.09e-01
C08 N07 N08 6.33e-05
R08 N07 N08 1.12e-01
C09 N08 N09 2.78e-05
R09 N08 N09 2.45e-02
L10 N09 N10 1.96e-10
R10 N09 N10 5.77e-02
L11 N10 N11 1.15e-11
R11 N10 N11 4.08e-02
C12 N11 N12 1.36e-06
L12 N11 N12 4.23e-11
R12 N11 N12 2.86e-02
C13 N12 N13 5.96e-07
L13 N12 N13 4.49e-11
R13 N12 N13 3.17e-02
C14 N13 N14 1.79e-11
L14 N13 N14 4.55e-11
R14 N13 N14 7.14e+00
C15 N14 Port2 1.74e-12
L15 N14 Port2 1.72e-10
R15 N14 Port2 2.46e+01
.ENDS GRM21BR71E334KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRM21BR71E475KA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E475KA73 Port1 Port2
C01 Port1 N01 2.67e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.69e-10
R03 N02 N03 4.55e-03
C04 N03 N04 1.52e-04
R04 N03 N04 1.46e+01
C05 N04 N05 1.28e-04
R05 N04 N05 2.36e+00
C06 N05 N06 1.02e-04
R06 N05 N06 4.04e-01
C07 N06 N07 8.44e-05
R07 N06 N07 6.05e-02
C08 N07 N08 6.12e-05
R08 N07 N08 1.06e-02
L09 N08 N09 3.12e-11
R09 N08 N09 3.22e-02
L10 N09 N10 2.19e-10
R10 N09 N10 2.22e-02
L11 N10 N11 7.62e-12
R11 N10 N11 2.01e-02
C12 N11 N12 1.17e-05
L12 N11 N12 4.23e-11
R12 N11 N12 6.92e-03
C13 N12 N13 3.90e-06
L13 N12 N13 5.94e-11
R13 N12 N13 8.73e-03
C14 N13 N14 1.53e-11
L14 N13 N14 5.29e-11
R14 N13 N14 9.02e+00
C15 N14 Port2 3.48e-12
L15 N14 Port2 7.43e-11
R15 N14 Port2 1.87e+01
.ENDS GRM21BR71E475KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRM21BR71E475MA73
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71E475MA73 Port1 Port2
C01 Port1 N01 2.67e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.69e-10
R03 N02 N03 4.55e-03
C04 N03 N04 1.52e-04
R04 N03 N04 1.46e+01
C05 N04 N05 1.28e-04
R05 N04 N05 2.36e+00
C06 N05 N06 1.02e-04
R06 N05 N06 4.04e-01
C07 N06 N07 8.44e-05
R07 N06 N07 6.05e-02
C08 N07 N08 6.12e-05
R08 N07 N08 1.06e-02
L09 N08 N09 3.12e-11
R09 N08 N09 3.22e-02
L10 N09 N10 2.19e-10
R10 N09 N10 2.22e-02
L11 N10 N11 7.62e-12
R11 N10 N11 2.01e-02
C12 N11 N12 1.17e-05
L12 N11 N12 4.23e-11
R12 N11 N12 6.92e-03
C13 N12 N13 3.90e-06
L13 N12 N13 5.94e-11
R13 N12 N13 8.73e-03
C14 N13 N14 1.53e-11
L14 N13 N14 5.29e-11
R14 N13 N14 9.02e+00
C15 N14 Port2 3.48e-12
L15 N14 Port2 7.43e-11
R15 N14 Port2 1.87e+01
.ENDS GRM21BR71E475MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRM21BR71H104KA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71H104KA01 Port1 Port2
C01 Port1 N01 9.67e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 7.66e-11
R03 N02 N03 1.45e-02
C04 N03 N04 1.59e-05
R04 N03 N04 2.50e+02
C05 N04 N05 2.80e-05
R05 N04 N05 2.22e+01
C06 N05 N06 1.82e-05
R06 N05 N06 7.71e+00
C07 N06 N07 1.87e-05
R07 N06 N07 1.01e+00
C08 N07 N08 4.13e-05
R08 N07 N08 1.93e-01
C09 N08 N09 2.21e-05
R09 N08 N09 7.70e-02
C10 N09 N10 1.37e-05
R10 N09 N10 3.92e-02
C11 N10 N11 7.58e-06
R11 N10 N11 1.26e-02
L12 N11 N12 4.51e-11
R12 N11 N12 2.65e-01
L13 N12 N13 1.20e-10
R13 N12 N13 8.93e-02
C14 N13 N14 4.91e-07
L14 N13 N14 2.99e-11
R14 N13 N14 3.39e-02
C15 N14 N15 9.88e-08
L15 N14 N15 6.61e-11
R15 N14 N15 4.82e-02
C16 N15 N16 1.67e-11
L16 N15 N16 5.76e-11
R16 N15 N16 5.64e+00
C17 N16 N17 3.41e-12
L17 N16 N17 1.11e-10
R17 N16 N17 1.35e+01
C18 N17 Port2 1.95e-12
L18 N17 Port2 9.64e-11
R18 N17 Port2 1.00e+05
.ENDS GRM21BR71H104KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GRM21BR71H104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71H104MA01 Port1 Port2
C01 Port1 N01 9.67e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 7.66e-11
R03 N02 N03 1.45e-02
C04 N03 N04 1.59e-05
R04 N03 N04 2.50e+02
C05 N04 N05 2.80e-05
R05 N04 N05 2.22e+01
C06 N05 N06 1.82e-05
R06 N05 N06 7.71e+00
C07 N06 N07 1.87e-05
R07 N06 N07 1.01e+00
C08 N07 N08 4.13e-05
R08 N07 N08 1.93e-01
C09 N08 N09 2.21e-05
R09 N08 N09 7.70e-02
C10 N09 N10 1.37e-05
R10 N09 N10 3.92e-02
C11 N10 N11 7.58e-06
R11 N10 N11 1.26e-02
L12 N11 N12 4.51e-11
R12 N11 N12 2.65e-01
L13 N12 N13 1.20e-10
R13 N12 N13 8.93e-02
C14 N13 N14 4.91e-07
L14 N13 N14 2.99e-11
R14 N13 N14 3.39e-02
C15 N14 N15 9.88e-08
L15 N14 N15 6.61e-11
R15 N14 N15 4.82e-02
C16 N15 N16 1.67e-11
L16 N15 N16 5.76e-11
R16 N15 N16 5.64e+00
C17 N16 N17 3.41e-12
L17 N16 N17 1.11e-10
R17 N16 N17 1.35e+01
C18 N17 Port2 1.95e-12
L18 N17 Port2 9.64e-11
R18 N17 Port2 1.00e+05
.ENDS GRM21BR71H104MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRM21BR71H105KA12
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71H105KA12 Port1 Port2
C01 Port1 N01 1.01e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 1.05e-10
R03 N02 N03 3.95e-03
C04 N03 N04 2.83e-05
R04 N03 N04 2.36e+02
C05 N04 N05 1.58e-04
R05 N04 N05 1.60e+00
C06 N05 N06 1.60e-04
R06 N05 N06 1.45e-01
C07 N06 N07 1.35e-04
R07 N06 N07 1.68e-02
C08 N07 N08 1.32e-04
R08 N07 N08 1.80e-03
L09 N08 N09 1.85e-10
R09 N08 N09 3.32e-02
L10 N09 N10 1.32e-11
R10 N09 N10 2.59e-02
C11 N10 N11 3.39e-06
L11 N10 N11 4.78e-11
R11 N10 N11 1.85e-02
C12 N11 N12 1.96e-06
L12 N11 N12 3.67e-11
R12 N11 N12 1.82e-02
C13 N12 N13 1.19e-11
L13 N12 N13 9.44e-11
R13 N12 N13 9.28e+00
C14 N13 Port2 2.35e-12
L14 N13 Port2 1.29e-10
R14 N13 Port2 1.85e+01
.ENDS GRM21BR71H105KA12
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-01[uF]/50[V]
* Murata P/N :GRM21BR71H154KA01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71H154KA01 Port1 Port2
C01 Port1 N01 1.48e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.74e-10
R03 N02 N03 1.01e-02
C04 N03 N04 1.90e-05
R04 N03 N04 2.10e+02
C05 N04 N05 3.06e-05
R05 N04 N05 2.20e+01
C06 N05 N06 2.23e-05
R06 N05 N06 4.38e+00
C07 N06 N07 1.89e-05
R07 N06 N07 5.75e-01
C08 N07 N08 1.40e-05
R08 N07 N08 6.73e-02
C09 N08 N09 1.71e-05
R09 N08 N09 7.05e-03
C10 N09 N10 9.23e-06
R10 N09 N10 2.88e-03
L11 N10 N11 2.25e-11
R11 N10 N11 9.02e-02
L12 N11 N12 1.80e-10
R12 N11 N12 7.23e-02
C13 N12 N13 8.48e-07
L13 N12 N13 3.05e-11
R13 N12 N13 2.43e-02
C14 N13 N14 2.27e-07
L14 N13 N14 5.38e-11
R14 N13 N14 3.51e-02
C15 N14 N15 8.40e-12
L15 N14 N15 9.82e-11
R15 N14 N15 1.03e+01
C16 N15 Port2 4.19e-12
L16 N15 Port2 8.37e-11
R16 N15 Port2 1.58e+01
.ENDS GRM21BR71H154KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GRM21BR71H224KA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71H224KA01 Port1 Port2
C01 Port1 N01 2.26e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.70e-10
R03 N02 N03 8.20e-03
C04 N03 N04 3.10e-05
R04 N03 N04 1.79e+02
C05 N04 N05 2.92e-05
R05 N04 N05 3.41e+01
C06 N05 N06 2.42e-05
R06 N05 N06 3.82e+00
C07 N06 N07 2.76e-05
R07 N06 N07 3.99e-01
C08 N07 N08 2.24e-05
R08 N07 N08 5.48e-02
C09 N08 N09 1.94e-05
R09 N08 N09 1.01e-02
L10 N09 N10 2.41e-11
R10 N09 N10 7.60e-02
L11 N10 N11 1.94e-10
R11 N10 N11 6.32e-02
C12 N11 N12 9.62e-07
L12 N11 N12 3.89e-11
R12 N11 N12 3.26e-02
C13 N12 N13 3.40e-07
L13 N12 N13 5.16e-11
R13 N12 N13 3.57e-02
C14 N13 N14 1.21e-11
L14 N13 N14 6.76e-11
R14 N13 N14 7.28e+00
C15 N14 Port2 5.28e-12
L15 N14 Port2 6.92e-11
R15 N14 Port2 1.53e+01
.ENDS GRM21BR71H224KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GRM21BR71H224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71H224MA01 Port1 Port2
C01 Port1 N01 2.26e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.70e-10
R03 N02 N03 8.20e-03
C04 N03 N04 3.10e-05
R04 N03 N04 1.79e+02
C05 N04 N05 2.92e-05
R05 N04 N05 3.41e+01
C06 N05 N06 2.42e-05
R06 N05 N06 3.82e+00
C07 N06 N07 2.76e-05
R07 N06 N07 3.99e-01
C08 N07 N08 2.24e-05
R08 N07 N08 5.48e-02
C09 N08 N09 1.94e-05
R09 N08 N09 1.01e-02
L10 N09 N10 2.41e-11
R10 N09 N10 7.60e-02
L11 N10 N11 1.94e-10
R11 N10 N11 6.32e-02
C12 N11 N12 9.62e-07
L12 N11 N12 3.89e-11
R12 N11 N12 3.26e-02
C13 N12 N13 3.40e-07
L13 N12 N13 5.16e-11
R13 N12 N13 3.57e-02
C14 N13 N14 1.21e-11
L14 N13 N14 6.76e-11
R14 N13 N14 7.28e+00
C15 N14 Port2 5.28e-12
L15 N14 Port2 6.92e-11
R15 N14 Port2 1.53e+01
.ENDS GRM21BR71H224MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRM21BR71H473KA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71H473KA01 Port1 Port2
C01 Port1 N01 4.69e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 2.04e-02
C04 N03 N04 6.37e-06
R04 N03 N04 5.38e+02
C05 N04 N05 7.89e-06
R05 N04 N05 6.33e+01
C06 N05 N06 6.97e-06
R06 N05 N06 8.34e+00
C07 N06 N07 8.44e-06
R07 N06 N07 9.13e-01
C08 N07 N08 6.32e-06
R08 N07 N08 2.80e-01
C09 N08 N09 3.65e-06
R09 N08 N09 6.23e-02
C10 N09 N10 2.57e-06
R10 N09 N10 1.34e-02
L11 N10 N11 1.02e-10
R11 N10 N11 1.45e-01
C12 N11 N12 2.32e-07
L12 N11 N12 3.18e-11
R12 N11 N12 4.95e-02
C13 N12 N13 3.38e-08
L13 N12 N13 6.26e-11
R13 N12 N13 5.68e-02
C14 N13 N14 1.67e-11
L14 N13 N14 7.82e-11
R14 N13 N14 6.21e+00
C15 N14 Port2 1.83e-12
L15 N14 Port2 1.62e-10
R15 N14 Port2 2.25e+01
.ENDS GRM21BR71H473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRM21BR71H473MA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71H473MA01 Port1 Port2
C01 Port1 N01 4.69e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 2.04e-02
C04 N03 N04 6.37e-06
R04 N03 N04 5.38e+02
C05 N04 N05 7.89e-06
R05 N04 N05 6.33e+01
C06 N05 N06 6.97e-06
R06 N05 N06 8.34e+00
C07 N06 N07 8.44e-06
R07 N06 N07 9.13e-01
C08 N07 N08 6.32e-06
R08 N07 N08 2.80e-01
C09 N08 N09 3.65e-06
R09 N08 N09 6.23e-02
C10 N09 N10 2.57e-06
R10 N09 N10 1.34e-02
L11 N10 N11 1.02e-10
R11 N10 N11 1.45e-01
C12 N11 N12 2.32e-07
L12 N11 N12 3.18e-11
R12 N11 N12 4.95e-02
C13 N12 N13 3.38e-08
L13 N12 N13 6.26e-11
R13 N12 N13 5.68e-02
C14 N13 N14 1.67e-11
L14 N13 N14 7.82e-11
R14 N13 N14 6.21e+00
C15 N14 Port2 1.83e-12
L15 N14 Port2 1.62e-10
R15 N14 Port2 2.25e+01
.ENDS GRM21BR71H473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GRM21BR71H474KA88
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71H474KA88 Port1 Port2
C01 Port1 N01 4.74e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.57e-10
R03 N02 N03 6.95e-03
C04 N03 N04 6.41e-05
R04 N03 N04 7.09e+01
C05 N04 N05 8.14e-05
R05 N04 N05 1.00e+01
C06 N05 N06 7.17e-05
R06 N05 N06 2.23e+00
C07 N06 N07 5.31e-05
R07 N06 N07 3.16e-01
C08 N07 N08 7.78e-05
R08 N07 N08 3.46e-02
C09 N08 N09 3.75e-05
R09 N08 N09 1.46e-02
C10 N09 N10 1.17e-04
R10 N09 N10 7.75e-04
L11 N10 N11 1.36e-10
R11 N10 N11 4.20e-02
L12 N11 N12 1.25e-11
R12 N11 N12 2.94e-02
C13 N12 N13 1.65e-06
L13 N12 N13 4.45e-11
R13 N12 N13 2.43e-02
C14 N13 N14 5.80e-07
L14 N13 N14 5.43e-11
R14 N13 N14 2.44e-02
C15 N14 N15 1.36e-11
L15 N14 N15 7.11e-11
R15 N14 N15 9.55e+00
C16 N15 Port2 2.23e-12
L16 N15 Port2 1.57e-10
R16 N15 Port2 2.57e+01
.ENDS GRM21BR71H474KA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GRM21BR71H474MA88
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71H474MA88 Port1 Port2
C01 Port1 N01 4.74e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.57e-10
R03 N02 N03 6.95e-03
C04 N03 N04 6.41e-05
R04 N03 N04 7.09e+01
C05 N04 N05 8.14e-05
R05 N04 N05 1.00e+01
C06 N05 N06 7.17e-05
R06 N05 N06 2.23e+00
C07 N06 N07 5.31e-05
R07 N06 N07 3.16e-01
C08 N07 N08 7.78e-05
R08 N07 N08 3.46e-02
C09 N08 N09 3.75e-05
R09 N08 N09 1.46e-02
C10 N09 N10 1.17e-04
R10 N09 N10 7.75e-04
L11 N10 N11 1.36e-10
R11 N10 N11 4.20e-02
L12 N11 N12 1.25e-11
R12 N11 N12 2.94e-02
C13 N12 N13 1.65e-06
L13 N12 N13 4.45e-11
R13 N12 N13 2.43e-02
C14 N13 N14 5.80e-07
L14 N13 N14 5.43e-11
R14 N13 N14 2.44e-02
C15 N14 N15 1.36e-11
L15 N14 N15 7.11e-11
R15 N14 N15 9.55e+00
C16 N15 Port2 2.23e-12
L16 N15 Port2 1.57e-10
R16 N15 Port2 2.57e+01
.ENDS GRM21BR71H474MA88
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GRM21BR71H683KA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR71H683KA01 Port1 Port2
C01 Port1 N01 6.81e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.71e-10
R03 N02 N03 1.98e-02
C04 N03 N04 9.16e-06
R04 N03 N04 4.03e+02
C05 N04 N05 1.40e-05
R05 N04 N05 4.13e+01
C06 N05 N06 1.12e-05
R06 N05 N06 8.43e+00
C07 N06 N07 1.02e-05
R07 N06 N07 1.11e+00
C08 N07 N08 9.18e-06
R08 N07 N08 2.13e-01
C09 N08 N09 6.68e-06
R09 N08 N09 4.00e-02
C10 N09 N10 3.17e-06
R10 N09 N10 1.22e-02
L11 N10 N11 1.31e-10
R11 N10 N11 1.07e-01
C12 N11 N12 6.53e-07
L12 N11 N12 1.65e-11
R12 N11 N12 2.41e-02
C13 N12 N13 6.83e-08
L13 N12 N13 7.25e-11
R13 N12 N13 4.98e-02
C14 N13 N14 8.68e-12
L14 N13 N14 1.29e-10
R14 N13 N14 9.84e+00
C15 N14 Port2 3.88e-12
L15 N14 Port2 9.77e-11
R15 N14 Port2 2.08e+01
.ENDS GRM21BR71H683KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRM21BR72A103KA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A103KA01 Port1 Port2
C01 Port1 N01 1.01e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 5.40e-02
C04 N03 N04 1.21e-06
R04 N03 N04 2.88e+03
C05 N04 N05 2.01e-06
R05 N04 N05 1.99e+02
C06 N05 N06 1.58e-06
R06 N05 N06 3.97e+01
C07 N06 N07 2.75e-06
R07 N06 N07 4.35e+00
C08 N07 N08 1.25e-06
R08 N07 N08 1.87e+00
C09 N08 N09 8.88e-07
R09 N08 N09 3.44e-01
C10 N09 N10 3.86e-07
R10 N09 N10 8.11e-02
L11 N10 N11 3.36e-11
R11 N10 N11 1.36e-01
L12 N11 N12 1.12e-12
R12 N11 N12 9.27e-03
C13 N12 N13 2.80e-08
L13 N12 N13 1.70e-11
R13 N12 N13 4.67e-02
C14 N13 N14 3.28e-08
L14 N13 N14 3.20e-12
R14 N13 N14 2.15e-02
C15 N14 N15 1.00e-11
L15 N14 N15 9.90e-11
R15 N14 N15 9.80e+00
C16 N15 Port2 2.81e-12
L16 N15 Port2 1.39e-10
R16 N15 Port2 2.44e+01
.ENDS GRM21BR72A103KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRM21BR72A103MA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A103MA01 Port1 Port2
C01 Port1 N01 1.01e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 5.40e-02
C04 N03 N04 1.21e-06
R04 N03 N04 2.88e+03
C05 N04 N05 2.01e-06
R05 N04 N05 1.99e+02
C06 N05 N06 1.58e-06
R06 N05 N06 3.97e+01
C07 N06 N07 2.75e-06
R07 N06 N07 4.35e+00
C08 N07 N08 1.25e-06
R08 N07 N08 1.87e+00
C09 N08 N09 8.88e-07
R09 N08 N09 3.44e-01
C10 N09 N10 3.86e-07
R10 N09 N10 8.11e-02
L11 N10 N11 3.36e-11
R11 N10 N11 1.36e-01
L12 N11 N12 1.12e-12
R12 N11 N12 9.27e-03
C13 N12 N13 2.80e-08
L13 N12 N13 1.70e-11
R13 N12 N13 4.67e-02
C14 N13 N14 3.28e-08
L14 N13 N14 3.20e-12
R14 N13 N14 2.15e-02
C15 N14 N15 1.00e-11
L15 N14 N15 9.90e-11
R15 N14 N15 9.80e+00
C16 N15 Port2 2.81e-12
L16 N15 Port2 1.39e-10
R16 N15 Port2 2.44e+01
.ENDS GRM21BR72A103MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GRM21BR72A104KAC4
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A104KAC4 Port1 Port2
C01 Port1 N01 1.02e-07
R01 Port1 N01 5.00e+09
L02 N01 N02 1.68e-10
R03 N02 N03 1.50e-02
C04 N03 N04 1.18e-05
R04 N03 N04 3.37e+02
C05 N04 N05 1.87e-05
R05 N04 N05 2.67e+01
C06 N05 N06 1.63e-05
R06 N05 N06 4.54e+00
C07 N06 N07 1.55e-05
R07 N06 N07 7.04e-01
C08 N07 N08 1.33e-05
R08 N07 N08 1.10e-01
C09 N08 N09 6.83e-06
R09 N08 N09 2.60e-02
L10 N09 N10 1.07e-10
R10 N09 N10 8.48e-02
L11 N10 N11 1.24e-11
R11 N10 N11 6.15e-02
C12 N11 N12 4.33e-07
L12 N11 N12 3.43e-11
R12 N11 N12 3.68e-02
C13 N12 N13 9.55e-08
L13 N12 N13 6.46e-11
R13 N12 N13 4.77e-02
C14 N13 N14 8.92e-12
L14 N13 N14 8.71e-11
R14 N13 N14 9.68e+00
C15 N14 Port2 3.01e-12
L15 N14 Port2 1.23e-10
R15 N14 Port2 2.06e+01
.ENDS GRM21BR72A104KAC4
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GRM21BR72A104MAC4
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A104MAC4 Port1 Port2
C01 Port1 N01 1.02e-07
R01 Port1 N01 5.00e+09
L02 N01 N02 1.68e-10
R03 N02 N03 1.50e-02
C04 N03 N04 1.18e-05
R04 N03 N04 3.37e+02
C05 N04 N05 1.87e-05
R05 N04 N05 2.67e+01
C06 N05 N06 1.63e-05
R06 N05 N06 4.54e+00
C07 N06 N07 1.55e-05
R07 N06 N07 7.04e-01
C08 N07 N08 1.33e-05
R08 N07 N08 1.10e-01
C09 N08 N09 6.83e-06
R09 N08 N09 2.60e-02
L10 N09 N10 1.07e-10
R10 N09 N10 8.48e-02
L11 N10 N11 1.24e-11
R11 N10 N11 6.15e-02
C12 N11 N12 4.33e-07
L12 N11 N12 3.43e-11
R12 N11 N12 3.68e-02
C13 N12 N13 9.55e-08
L13 N12 N13 6.46e-11
R13 N12 N13 4.77e-02
C14 N13 N14 8.92e-12
L14 N13 N14 8.71e-11
R14 N13 N14 9.68e+00
C15 N14 Port2 3.01e-12
L15 N14 Port2 1.23e-10
R15 N14 Port2 2.06e+01
.ENDS GRM21BR72A104MAC4
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GRM21BR72A153KA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A153KA01 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 3.79e-02
C04 N03 N04 1.83e-06
R04 N03 N04 2.02e+03
C05 N04 N05 3.88e-06
R05 N04 N05 2.16e+02
C06 N05 N06 2.37e-06
R06 N05 N06 6.38e+01
C07 N06 N07 2.07e-06
R07 N06 N07 9.23e+00
C08 N07 N08 1.66e-06
R08 N07 N08 1.28e+00
C09 N08 N09 1.47e-06
R09 N08 N09 2.14e-01
C10 N09 N10 1.16e-06
R10 N09 N10 6.45e-02
C11 N10 N11 4.89e-07
R11 N10 N11 2.25e-02
L12 N11 N12 1.03e-10
R12 N11 N12 1.53e-01
C13 N12 N13 9.59e-08
L13 N12 N13 2.19e-11
R13 N12 N13 5.38e-02
C14 N13 N14 1.67e-08
L14 N13 N14 5.33e-11
R14 N13 N14 1.04e-01
C15 N14 N15 1.21e-11
L15 N14 N15 1.33e-10
R15 N14 N15 9.88e+00
C16 N15 Port2 1.91e-12
L16 N15 Port2 1.79e-10
R16 N15 Port2 1.86e+01
.ENDS GRM21BR72A153KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GRM21BR72A223KA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A223KA01 Port1 Port2
C01 Port1 N01 2.18e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 7.55e-11
R03 N02 N03 3.67e-02
C04 N03 N04 2.20e-06
R04 N03 N04 1.68e+03
C05 N04 N05 4.50e-06
R05 N04 N05 8.81e+01
C06 N05 N06 3.18e-06
R06 N05 N06 1.84e+01
C07 N06 N07 4.60e-06
R07 N06 N07 1.84e+00
C08 N07 N08 2.74e-06
R08 N07 N08 7.76e-01
C09 N08 N09 1.77e-06
R09 N08 N09 1.62e-01
C10 N09 N10 1.09e-06
R10 N09 N10 3.65e-02
L11 N10 N11 1.18e-10
R11 N10 N11 2.06e-01
C12 N11 N12 9.71e-08
L12 N11 N12 2.61e-11
R12 N11 N12 5.02e-02
C13 N12 N13 3.57e-08
L13 N12 N13 3.09e-11
R13 N12 N13 6.82e-02
C14 N13 N14 1.71e-11
L14 N13 N14 8.81e-11
R14 N13 N14 6.03e+00
C15 N14 Port2 1.20e-12
L15 N14 Port2 2.51e-10
R15 N14 Port2 2.65e+01
.ENDS GRM21BR72A223KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GRM21BR72A223MA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A223MA01 Port1 Port2
C01 Port1 N01 2.18e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 7.55e-11
R03 N02 N03 3.67e-02
C04 N03 N04 2.20e-06
R04 N03 N04 1.68e+03
C05 N04 N05 4.50e-06
R05 N04 N05 8.81e+01
C06 N05 N06 3.18e-06
R06 N05 N06 1.84e+01
C07 N06 N07 4.60e-06
R07 N06 N07 1.84e+00
C08 N07 N08 2.74e-06
R08 N07 N08 7.76e-01
C09 N08 N09 1.77e-06
R09 N08 N09 1.62e-01
C10 N09 N10 1.09e-06
R10 N09 N10 3.65e-02
L11 N10 N11 1.18e-10
R11 N10 N11 2.06e-01
C12 N11 N12 9.71e-08
L12 N11 N12 2.61e-11
R12 N11 N12 5.02e-02
C13 N12 N13 3.57e-08
L13 N12 N13 3.09e-11
R13 N12 N13 6.82e-02
C14 N13 N14 1.71e-11
L14 N13 N14 8.81e-11
R14 N13 N14 6.03e+00
C15 N14 Port2 1.20e-12
L15 N14 Port2 2.51e-10
R15 N14 Port2 2.65e+01
.ENDS GRM21BR72A223MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-02[uF]/100[V]
* Murata P/N :GRM21BR72A333KA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A333KA01 Port1 Port2
C01 Port1 N01 3.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.05e-10
R03 N02 N03 2.46e-02
C04 N03 N04 4.35e-06
R04 N03 N04 7.88e+02
C05 N04 N05 9.02e-06
R05 N04 N05 8.64e+01
C06 N05 N06 5.40e-06
R06 N05 N06 2.43e+01
C07 N06 N07 4.99e-06
R07 N06 N07 3.00e+00
C08 N07 N08 3.61e-06
R08 N07 N08 4.70e-01
C09 N08 N09 2.36e-06
R09 N08 N09 6.52e-02
C10 N09 N10 2.25e-06
R10 N09 N10 1.31e-02
L11 N10 N11 1.08e-10
R11 N10 N11 1.61e-01
C12 N11 N12 1.83e-07
L12 N11 N12 2.91e-11
R12 N11 N12 5.07e-02
C13 N12 N13 4.70e-08
L13 N12 N13 3.45e-11
R13 N12 N13 5.97e-02
C14 N13 N14 1.22e-11
L14 N13 N14 1.17e-10
R14 N13 N14 1.19e+01
C15 N14 Port2 2.91e-12
L15 N14 Port2 1.26e-10
R15 N14 Port2 1.50e+01
.ENDS GRM21BR72A333KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GRM21BR72A473KA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A473KA01 Port1 Port2
C01 Port1 N01 4.78e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.52e-11
R03 N02 N03 2.22e-02
C04 N03 N04 6.51e-06
R04 N03 N04 5.68e+02
C05 N04 N05 9.42e-06
R05 N04 N05 5.06e+01
C06 N05 N06 7.95e-06
R06 N05 N06 8.02e+00
C07 N06 N07 7.24e-06
R07 N06 N07 1.19e+00
C08 N07 N08 6.77e-06
R08 N07 N08 2.01e-01
C09 N08 N09 5.16e-06
R09 N08 N09 5.69e-02
C10 N09 N10 2.85e-06
R10 N09 N10 1.66e-02
L11 N10 N11 1.13e-10
R11 N10 N11 1.47e-01
L12 N11 N12 1.68e-11
R12 N11 N12 1.00e-01
C13 N12 N13 1.93e-07
L13 N12 N13 3.78e-11
R13 N12 N13 4.67e-02
C14 N13 N14 5.94e-08
L14 N13 N14 3.79e-11
R14 N13 N14 4.47e-02
C15 N14 N15 1.30e-11
L15 N14 N15 9.02e-11
R15 N14 N15 5.87e+00
C16 N15 Port2 1.36e-12
L16 N15 Port2 1.98e-10
R16 N15 Port2 2.85e+01
.ENDS GRM21BR72A473KA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GRM21BR72A473MA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A473MA01 Port1 Port2
C01 Port1 N01 4.78e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.52e-11
R03 N02 N03 2.22e-02
C04 N03 N04 6.51e-06
R04 N03 N04 5.68e+02
C05 N04 N05 9.42e-06
R05 N04 N05 5.06e+01
C06 N05 N06 7.95e-06
R06 N05 N06 8.02e+00
C07 N06 N07 7.24e-06
R07 N06 N07 1.19e+00
C08 N07 N08 6.77e-06
R08 N07 N08 2.01e-01
C09 N08 N09 5.16e-06
R09 N08 N09 5.69e-02
C10 N09 N10 2.85e-06
R10 N09 N10 1.66e-02
L11 N10 N11 1.13e-10
R11 N10 N11 1.47e-01
L12 N11 N12 1.68e-11
R12 N11 N12 1.00e-01
C13 N12 N13 1.93e-07
L13 N12 N13 3.78e-11
R13 N12 N13 4.67e-02
C14 N13 N14 5.94e-08
L14 N13 N14 3.79e-11
R14 N13 N14 4.47e-02
C15 N14 N15 1.30e-11
L15 N14 N15 9.02e-11
R15 N14 N15 5.87e+00
C16 N15 Port2 1.36e-12
L16 N15 Port2 1.98e-10
R16 N15 Port2 2.85e+01
.ENDS GRM21BR72A473MA01
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/100[V]
* Murata P/N :GRM21BR72A474KA73
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A474KA73 Port1 Port2
C01 Port1 N01 4.60e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.69e-10
R03 N02 N03 5.67e-03
C04 N03 N04 8.03e-05
R04 N03 N04 5.66e+01
C05 N04 N05 9.74e-05
R05 N04 N05 8.97e+00
C06 N05 N06 8.37e-05
R06 N05 N06 1.10e+00
C07 N06 N07 6.33e-05
R07 N06 N07 1.45e-01
C08 N07 N08 5.44e-05
R08 N07 N08 1.70e-02
L09 N08 N09 1.36e-11
R09 N08 N09 6.02e-02
L10 N09 N10 1.65e-10
R10 N09 N10 5.27e-02
C11 N10 N11 1.26e-06
L11 N10 N11 6.00e-11
R11 N10 N11 3.36e-02
C12 N11 N12 6.71e-07
L12 N11 N12 4.41e-11
R12 N11 N12 2.67e-02
C13 N12 N13 1.97e-11
L13 N12 N13 4.27e-11
R13 N12 N13 3.82e+00
C14 N13 Port2 5.94e-12
L14 N13 Port2 5.62e-11
R14 N13 Port2 7.13e+00
.ENDS GRM21BR72A474KA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/100[V]
* Murata P/N :GRM21BR72A474MA73
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A474MA73 Port1 Port2
C01 Port1 N01 4.60e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.69e-10
R03 N02 N03 5.67e-03
C04 N03 N04 8.03e-05
R04 N03 N04 5.66e+01
C05 N04 N05 9.74e-05
R05 N04 N05 8.97e+00
C06 N05 N06 8.37e-05
R06 N05 N06 1.10e+00
C07 N06 N07 6.33e-05
R07 N06 N07 1.45e-01
C08 N07 N08 5.44e-05
R08 N07 N08 1.70e-02
L09 N08 N09 1.36e-11
R09 N08 N09 6.02e-02
L10 N09 N10 1.65e-10
R10 N09 N10 5.27e-02
C11 N10 N11 1.26e-06
L11 N10 N11 6.00e-11
R11 N10 N11 3.36e-02
C12 N11 N12 6.71e-07
L12 N11 N12 4.41e-11
R12 N11 N12 2.67e-02
C13 N12 N13 1.97e-11
L13 N12 N13 4.27e-11
R13 N12 N13 3.82e+00
C14 N13 Port2 5.94e-12
L14 N13 Port2 5.62e-11
R14 N13 Port2 7.13e+00
.ENDS GRM21BR72A474MA73
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/100[V]
* Murata P/N :GRM21BR72A683KAC4
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A683KAC4 Port1 Port2
C01 Port1 N01 7.16e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.43e-10
R03 N02 N03 1.98e-02
C04 N03 N04 1.18e-05
R04 N03 N04 2.91e+02
C05 N04 N05 1.79e-05
R05 N04 N05 3.75e+01
C06 N05 N06 1.22e-05
R06 N05 N06 7.84e+00
C07 N06 N07 1.03e-05
R07 N06 N07 1.13e+00
C08 N07 N08 7.52e-06
R08 N07 N08 1.64e-01
C09 N08 N09 4.26e-06
R09 N08 N09 2.56e-02
L10 N09 N10 9.41e-11
R10 N09 N10 9.83e-02
L11 N10 N11 4.48e-12
R11 N10 N11 9.60e-02
C12 N11 N12 3.56e-07
L12 N11 N12 2.62e-11
R12 N11 N12 2.48e-02
C13 N12 N13 6.80e-08
L13 N12 N13 4.76e-11
R13 N12 N13 4.17e-02
C14 N13 N14 9.87e-12
L14 N13 N14 1.41e-10
R14 N13 N14 1.41e+01
C15 N14 Port2 2.32e-12
L15 N14 Port2 1.64e-10
R15 N14 Port2 2.55e+01
.ENDS GRM21BR72A683KAC4
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/100[V]
* Murata P/N :GRM21BR72A683MAC4
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72A683MAC4 Port1 Port2
C01 Port1 N01 7.16e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.43e-10
R03 N02 N03 1.98e-02
C04 N03 N04 1.18e-05
R04 N03 N04 2.91e+02
C05 N04 N05 1.79e-05
R05 N04 N05 3.75e+01
C06 N05 N06 1.22e-05
R06 N05 N06 7.84e+00
C07 N06 N07 1.03e-05
R07 N06 N07 1.13e+00
C08 N07 N08 7.52e-06
R08 N07 N08 1.64e-01
C09 N08 N09 4.26e-06
R09 N08 N09 2.56e-02
L10 N09 N10 9.41e-11
R10 N09 N10 9.83e-02
L11 N10 N11 4.48e-12
R11 N10 N11 9.60e-02
C12 N11 N12 3.56e-07
L12 N11 N12 2.62e-11
R12 N11 N12 2.48e-02
C13 N12 N13 6.80e-08
L13 N12 N13 4.76e-11
R13 N12 N13 4.17e-02
C14 N13 N14 9.87e-12
L14 N13 N14 1.41e-10
R14 N13 N14 1.41e+01
C15 N14 Port2 2.32e-12
L15 N14 Port2 1.64e-10
R15 N14 Port2 2.55e+01
.ENDS GRM21BR72A683MAC4
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/200[V]
* Murata P/N :GRM21BR72D103KW03
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72D103KW03 Port1 Port2
C01 Port1 N01 9.57e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 7.09e-02
C04 N03 N04 6.09e-07
R04 N03 N04 3.73e+00
C05 N04 N05 7.36e-07
R05 N04 N05 3.60e-01
C06 N05 N06 7.15e-07
R06 N05 N06 6.54e-02
C07 N06 N07 2.77e-07
R07 N06 N07 2.62e-02
L08 N07 N08 3.29e-11
R08 N07 N08 1.45e-01
L09 N08 N09 2.74e-11
R09 N08 N09 2.06e-01
C10 N09 N10 1.34e-12
L10 N09 N10 3.10e-10
R10 N09 N10 1.74e+01
C11 N10 N11 1.21e-11
L11 N10 N11 1.72e-10
R11 N10 N11 1.24e+01
C12 N11 N12 6.25e-09
L12 N11 N12 4.82e-11
R12 N11 N12 1.01e-01
C13 N12 Port2 1.88e-07
L13 N12 Port2 5.25e-12
R13 N12 Port2 1.26e-02
.ENDS GRM21BR72D103KW03
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/200[V]
* Murata P/N :GRM21BR72D153KW03
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72D153KW03 Port1 Port2
C01 Port1 N01 1.42e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 1.19e-10
R03 N02 N03 6.13e-02
C04 N03 N04 7.69e-07
R04 N03 N04 1.68e+00
C05 N04 N05 7.15e-07
R05 N04 N05 1.22e-01
L06 N05 N06 9.43e-11
R06 N05 N06 1.39e-01
C07 N06 N07 3.83e-08
L07 N06 N07 2.11e-11
R07 N06 N07 3.91e-02
C08 N07 N08 9.53e-12
L08 N07 N08 2.30e-10
R08 N07 N08 1.69e+01
C09 N08 N09 6.93e-12
L09 N08 N09 1.23e-10
R09 N08 N09 1.06e+01
C10 N09 Port2 3.67e-12
L10 N09 Port2 1.09e-10
R10 N09 Port2 1.30e+01
.ENDS GRM21BR72D153KW03
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/200[V]
* Murata P/N :GRM21BR72D223KW03
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72D223KW03 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 1.28e-10
R03 N02 N03 4.54e-02
C04 N03 N04 1.23e-06
R04 N03 N04 1.24e+00
C05 N04 N05 1.08e-06
R05 N04 N05 9.07e-02
L06 N05 N06 1.29e-10
R06 N05 N06 1.68e-01
C07 N06 N07 2.93e-08
L07 N06 N07 4.25e-11
R07 N06 N07 6.19e-02
C08 N07 N08 1.22e-11
L08 N07 N08 1.32e-10
R08 N07 N08 1.31e+01
C09 N08 N09 4.79e-12
L09 N08 N09 1.38e-10
R09 N08 N09 1.04e+01
C10 N09 Port2 5.02e-12
L10 N09 Port2 8.19e-11
R10 N09 Port2 1.80e+01
.ENDS GRM21BR72D223KW03
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/250[V]
* Murata P/N :GRM21BR72E103KW03
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72E103KW03 Port1 Port2
C01 Port1 N01 9.57e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 7.09e-02
C04 N03 N04 6.09e-07
R04 N03 N04 3.73e+00
C05 N04 N05 7.36e-07
R05 N04 N05 3.60e-01
C06 N05 N06 7.15e-07
R06 N05 N06 6.54e-02
C07 N06 N07 2.77e-07
R07 N06 N07 2.62e-02
L08 N07 N08 3.29e-11
R08 N07 N08 1.45e-01
L09 N08 N09 2.74e-11
R09 N08 N09 2.06e-01
C10 N09 N10 1.34e-12
L10 N09 N10 3.10e-10
R10 N09 N10 1.74e+01
C11 N10 N11 1.21e-11
L11 N10 N11 1.72e-10
R11 N10 N11 1.24e+01
C12 N11 N12 6.25e-09
L12 N11 N12 4.82e-11
R12 N11 N12 1.01e-01
C13 N12 Port2 1.88e-07
L13 N12 Port2 5.25e-12
R13 N12 Port2 1.26e-02
.ENDS GRM21BR72E103KW03
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/250[V]
* Murata P/N :GRM21BR72E153KW03
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72E153KW03 Port1 Port2
C01 Port1 N01 1.42e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 1.19e-10
R03 N02 N03 6.13e-02
C04 N03 N04 7.69e-07
R04 N03 N04 1.68e+00
C05 N04 N05 7.15e-07
R05 N04 N05 1.22e-01
L06 N05 N06 9.43e-11
R06 N05 N06 1.39e-01
C07 N06 N07 3.83e-08
L07 N06 N07 2.11e-11
R07 N06 N07 3.91e-02
C08 N07 N08 9.53e-12
L08 N07 N08 2.30e-10
R08 N07 N08 1.69e+01
C09 N08 N09 6.93e-12
L09 N08 N09 1.23e-10
R09 N08 N09 1.06e+01
C10 N09 Port2 3.67e-12
L10 N09 Port2 1.09e-10
R10 N09 Port2 1.30e+01
.ENDS GRM21BR72E153KW03
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/250[V]
* Murata P/N :GRM21BR72E223KW03
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72E223KW03 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 1.28e-10
R03 N02 N03 4.54e-02
C04 N03 N04 1.23e-06
R04 N03 N04 1.24e+00
C05 N04 N05 1.08e-06
R05 N04 N05 9.07e-02
L06 N05 N06 1.29e-10
R06 N05 N06 1.68e-01
C07 N06 N07 2.93e-08
L07 N06 N07 4.25e-11
R07 N06 N07 6.19e-02
C08 N07 N08 1.22e-11
L08 N07 N08 1.32e-10
R08 N07 N08 1.31e+01
C09 N08 N09 4.79e-12
L09 N08 N09 1.38e-10
R09 N08 N09 1.04e+01
C10 N09 Port2 5.02e-12
L10 N09 Port2 8.19e-11
R10 N09 Port2 1.80e+01
.ENDS GRM21BR72E223KW03
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/500[V]
* Murata P/N :GRM21BR72H103KW09
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR72H103KW09 Port1 Port2
C01 Port1 N01 9.57e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 7.09e-02
C04 N03 N04 6.09e-07
R04 N03 N04 3.73e+00
C05 N04 N05 7.36e-07
R05 N04 N05 3.60e-01
C06 N05 N06 7.15e-07
R06 N05 N06 6.54e-02
C07 N06 N07 2.77e-07
R07 N06 N07 2.62e-02
L08 N07 N08 3.29e-11
R08 N07 N08 1.45e-01
L09 N08 N09 2.74e-11
R09 N08 N09 2.06e-01
C10 N09 N10 1.34e-12
L10 N09 N10 3.10e-10
R10 N09 N10 1.74e+01
C11 N10 N11 1.21e-11
L11 N10 N11 1.72e-10
R11 N10 N11 1.24e+01
C12 N11 N12 6.25e-09
L12 N11 N12 4.82e-11
R12 N11 N12 1.01e-01
C13 N12 Port2 1.88e-07
L13 N12 Port2 5.25e-12
R13 N12 Port2 1.26e-02
.ENDS GRM21BR72H103KW09
*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/500[V]
* Murata P/N :GRM21BR7LU103KW01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 31, 2023
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM21BR7LU103KW01 Port1 Port2
C01 Port1 N01 9.57e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 7.09e-02
C04 N03 N04 6.09e-07
R04 N03 N04 3.73e+00
C05 N04 N05 7.36e-07
R05 N04 N05 3.60e-01
C06 N05 N06 7.15e-07
R06 N05 N06 6.54e-02
C07 N06 N07 2.77e-07
R07 N06 N07 2.62e-02
L08 N07 N08 3.29e-11
R08 N07 N08 1.45e-01
L09 N08 N09 2.74e-11
R09 N08 N09 2.06e-01
C10 N09 N10 1.34e-12
L10 N09 N10 3.10e-10
R10 N09 N10 1.74e+01
C11 N10 N11 1.21e-11
L11 N10 N11 1.72e-10
R11 N10 N11 1.24e+01
C12 N11 N12 6.25e-09
L12 N11 N12 4.82e-11
R12 N11 N12 1.01e-01
C13 N12 Port2 1.88e-07
L13 N12 Port2 5.25e-12
R13 N12 Port2 1.26e-02
.ENDS GRM21BR7LU103KW01

